// Phase 4 stage 1 host test (3 Nov 2026, Vault spec 7f): the REAL
// pk_records.cpp (through rk_host.cpp and its G0 VAULT model) with password
// entries (kind 2), 200 records, 3-digit slot keys, the 128 KB backup body,
// and the nvs_vault growth check against real NVS images made by ESP-IDF's
// own generator (esp-idf-nvs-partition-gen, images in ../../p4s1/nvsgen).
#include "Arduino.h"
#include "rk_host.cpp"
#include "../src/vault_backup.h"
#include <vector>
#include <string>
#include <cstdio>
S Serial; std::map<std::string, std::vector<uint8_t>> g_nvs;
extern int g_vaultOpenLeft;
static int pass = 0, fail = 0;
static void check(bool c, const char* m) { (c ? pass : fail)++; printf("%s %s\n", c ? "PASS" : "FAIL", m); }
using namespace favilla;

static RkPass mk(const char* site, const char* user, const char* pw, const char* note = "", int slot = -1) {
  RkPass p; memset(&p, 0, sizeof p); p.slot = slot;
  strncpy(p.site, site, RK_SITE_MAX); strncpy(p.user, user, RK_PW_FIELD_MAX); strncpy(p.pass, pw, RK_PW_FIELD_MAX); strncpy(p.note, note, RK_PW_FIELD_MAX);
  p.policy = 0x14070001; return p;
}
static int pk(const char* site, uint8_t h, const char* name) { uint8_t id34[34] = {1, 1}; id34[2] = h; return rk_save(site, strlen(site), &h, 1, name, strlen(name), "", 0, id34); }
static std::vector<uint8_t> load(const char* f) { std::vector<uint8_t> v; FILE* fp = fopen(f, "rb"); if (!fp) return v; uint8_t b[4096]; size_t n; while ((n = fread(b, 1, sizeof b, fp)) > 0) v.insert(v.end(), b, b + n); fclose(fp); return v; }
static bool allFF(size_t a, size_t b) { for (size_t i = a; i < b; i++) if (g_part[i] != 0xFF) return false; return true; }
static int vaultCalls() { return g_vaultCalls[1] + g_vaultCalls[2] + g_vaultCalls[3]; }

int main() {
  setvbuf(stdout, nullptr, _IONBF, 0);
  const char* G = "../../p4s1/nvsgen/";
  // ---- 1. growth check against real NVS images ----
  {
    bool up; std::vector<uint8_t> a = load((std::string(G) + "a.bin").c_str()), b = load((std::string(G) + "b.bin").c_str()),
                                    c = load((std::string(G) + "c.bin").c_str()), d = load((std::string(G) + "d.bin").c_str());
    check(a.size() == 0x20000 && c.size() == 0x10000 && d.size() == 0x10000, "real NVS images loaded (generated by ESP-IDF's nvs_partition_gen)");
    R = (RkRam*)calloc(1, sizeof(RkRam));
    g_part = a; uint32_t v = rkScan(esp_partition_find_first(ESP_PARTITION_TYPE_DATA, ESP_PARTITION_SUBTYPE_DATA_NVS, "nvs_vault"), &up);
    check(v == 0x20000 && up, "grown vault: the scan finds vsz = 128 KB in a real NVS page (layout, bitmap and key offsets right)");
    g_part = b; v = rkScan(esp_partition_find_first(ESP_PARTITION_TYPE_DATA, ESP_PARTITION_SUBTYPE_DATA_NVS, "nvs_vault"), &up);
    check(v == 0 && up, "no marker: none found, upper half seen as in use");
    // old 64 KB vault + stale nvs_game pages above it
    g_part = c; g_part.insert(g_part.end(), d.begin(), d.end());
    v = rkScan(esp_partition_find_first(ESP_PARTITION_TYPE_DATA, ESP_PARTITION_SUBTYPE_DATA_NVS, "nvs_vault"), &up);
    check(v == 0 && up, "old vault + old game pages: the game's own u8 'vsz' is not taken as the marker");
    std::vector<uint8_t> lower(g_part.begin(), g_part.begin() + 0x10000);
    g_partErases = 0; rkGrowCheck();
    check(g_partErases == 1 && allFF(0x10000, 0x20000) && std::equal(lower.begin(), lower.end(), g_part.begin()), "growth: the upper 64 KB erased, the first 64 KB (the records) untouched");
    g_partErases = 0; g_part = c; g_part.resize(0x20000, 0xFF); rkGrowCheck();
    check(g_partErases == 0, "growth with an empty upper half: nothing erased");
    g_partErases = 0; g_part = a; rkGrowCheck();
    check(g_partErases == 0 && g_part == a, "already grown (marker present): nothing erased even though records sit past 64 KB");
    g_partErases = 0; g_part = c; rkGrowCheck();
    check(g_partErases == 0 && g_part == c, "the old 64 KB table: nothing to do");
    // the marker entry erased (state 00), e.g. by a wipe's clear(): not trusted
    g_part = a; bool flipped = false;
    for (uint32_t off = 0; off < g_part.size() && !flipped; off += 4096) for (uint32_t e = 0; e < 126; e++) {
      uint8_t* it = g_part.data() + off + 64 + e * 32;
      if (((g_part[off + 32 + e / 4] >> ((e % 4) * 2)) & 3) == 2 && !memcmp(it + 8, "vsz", 4)) { g_part[off + 32 + e / 4] &= (uint8_t)~(3 << ((e % 4) * 2)); flipped = true; break; }
    }
    v = rkScan(esp_partition_find_first(ESP_PARTITION_TYPE_DATA, ESP_PARTITION_SUBTYPE_DATA_NVS, "nvs_vault"), &up);
    check(flipped && v == 0, "an erased marker entry is not trusted");
    free(R); R = nullptr; g_part.clear();
  }
  // ---- 2. mount writes the marker ----
  {
    g_part.assign(0x20000, 0xFF);
    rk_mount();
    Preferences p; p.begin("pkrec", true, "nvs_vault");
    check(p.getUInt("vsz", 0) == 0x20000, "mount at 128 KB writes vsz");
    rk_wipe_all();
    check(p.getUInt("vsz", 0) == 0x20000 && p.getUChar("ver", 0) == 1, "a wipe keeps ver and vsz");
    g_part.clear();
  }
  // ---- 3. password entries ----
  {
    rk_wipe_all();
    check(rk_pw_check(0, 0, 1, 0) == RK_E_SIZE && rk_pw_check(5, 0, 0, 0) == RK_E_SIZE, "check: an empty site or password is refused");
    check(rk_pw_check(5, 129, 5, 0) == RK_E_SIZE && rk_pw_check(5, 0, 129, 0) == RK_E_SIZE && rk_pw_check(5, 0, 5, 129) == RK_E_SIZE, "check: any field over 128 is refused");
    check(rk_pw_check(159, 128, 128, 0) == RK_OK && rk_pw_check(160, 128, 128, 0) == RK_E_SIZE, "check: the sum is held to 431 (site 159 + 128 + 128 + 16 fits, one more does not)");
    pk("github.com", 0xA1, "josh");
    RkPass e = mk("github.com", "josh@favilla.io", "correct horse battery", "work account"); int slot = -1;
    int r = rk_pw_save(&e, &slot);
    check(r == RK_OK && slot == 1 && rk_pw_count() == 1 && rk_count() == 1 && rk_count_all() == 2, "a password saved next to a passkey of the same site: counts kept apart");
    rk_forget_cache(); g_vaultOpenLeft = 32; int c0 = g_vaultCalls[2];
    RkAcct acc[4]; int n = rk_find("github.com", 10, acc, 4);
    check(n == 1 && !strcmp(acc[0].name, "josh") && g_vaultCalls[2] - c0 == 1, "passkey sign-in on the site opens only the passkey (no OPEN spent on the password)");
    RkAcct a0; check(rk_at(0, &a0) == RK_OK && !strcmp(a0.name, "josh") && rk_at(1, &a0) != RK_OK, "rk_at lists passkeys only");
    RkPass o; c0 = g_vaultCalls[2];
    r = rk_pw_open(0, &o);
    check(r == RK_OK && !strcmp(o.site, "github.com") && !strcmp(o.user, "josh@favilla.io") && !strcmp(o.pass, "correct horse battery") && !strcmp(o.note, "work account") && o.policy == 0x14070001 && o.created && o.updated, "the entry opens with every field");
    rk_pw_open(0, &o);
    check(g_vaultCalls[2] - c0 == 2, "passwords are never cached: each open is an OPEN");
    uint32_t created = o.created, upd = o.updated;
    // same site + username: replaced, id kept
    uint8_t id0[8]; memcpy(id0, R->idx[1].clear, 8);
    RkPass e2 = mk("github.com", "josh@favilla.io", "new password 2026"); r = rk_pw_save(&e2, &slot);
    check(r == RK_OK && slot == 1 && rk_pw_count() == 1 && !memcmp(R->idx[1].clear, id0, 8), "the same site and username replaces the entry (same id)");
    rk_pw_open(0, &o);
    check(!strcmp(o.pass, "new password 2026") && o.updated > upd, "...with the new password and a newer time");
    // another username: a second entry
    RkPass e3 = mk("github.com", "alicia", "pw3"); rk_pw_save(&e3, &slot);
    check(rk_pw_count() == 2 && slot == 2, "another username on the site: a second entry");
    // edit by slot (rename the username), id kept, created kept when given
    RkPass ed = o; ed.slot = 1; strcpy(ed.user, "josh.c"); r = rk_pw_save(&ed, &slot);
    rk_pw_open(0, &o);
    check(r == RK_OK && slot == 1 && !strcmp(o.user, "josh.c") && o.created == created && !memcmp(R->idx[1].clear, id0, 8), "edit by slot: username changed, id and created kept");
    // a passkey slot given as the edit slot is not overwritten
    RkPass bad = mk("x.example", "u", "p", "", 0); rk_pw_save(&bad, &slot);
    check(slot != 0 && rk_count() == 1, "a passkey's slot passed as an edit: ignored, a new entry is added instead");
    // largest entry seals and opens
    RkPass big; memset(&big, 0, sizeof big); big.slot = -1; memset(big.site, 's', 159); memset(big.user, 'u', 128); memset(big.pass, 'p', 128);
    r = rk_pw_save(&big, &slot); RkPass ob; int bi = -1; for (int i = 0; i < rk_pw_count(); i++) if (rk_pw_slot_at(i) == slot) bi = i;
    check(r == RK_OK && rk_pw_open(bi, &ob) == RK_OK && strlen(ob.site) == 159 && strlen(ob.pass) == 128, "the largest entry (431 bytes) seals and opens");
    RkPass over = big; over.site[159] = 's'; check(rk_pw_save(&over, nullptr) == RK_E_SIZE, "...one byte more is refused before the G0");
    // delete: tombstoned, gone
    int before = rk_pw_count(); r = rk_delete(rk_pw_slot_at(0));
    check(r == RK_OK && rk_pw_count() == before - 1, "a password entry deletes by slot");
    rk_pw_wipe(&o); rk_pw_wipe(&ob);
    check(o.pass[0] == 0 && o.site[0] == 0, "rk_pw_wipe clears the entry");
    // reboot: index reload keeps kinds
    int pc = rk_pw_count(), kc = rk_count(); rk_test_reboot();
    check(rk_pw_count() == pc && rk_count() == kc, "after a reboot the index reloads with both kinds");
  }
  // ---- 4. 200 records, 3-digit keys, full ----
  {
    rk_wipe_all(); g_vaultOpenLeft = 32;
    int ok = 0;
    for (int i = 0; i < RK_MAX; i++) {
      char s[40]; snprintf(s, sizeof s, "site%03d.example", i);
      if (i % 4 == 0) ok += pk(s, (uint8_t)i, "acct") == RK_OK;
      else { RkPass e = mk(s, "user", "pw-0123456789"); ok += rk_pw_save(&e, nullptr) == RK_OK; }
    }
    check(ok == RK_MAX && rk_count_all() == 200 && rk_count() == 50 && rk_pw_count() == 150, "200 records saved, 50 passkeys and 150 passwords");
    check(g_nvs.count("nvs_vault/pkrec/r99") && g_nvs.count("nvs_vault/pkrec/r100") && g_nvs.count("nvs_vault/pkrec/r199") && !g_nvs.count("nvs_vault/pkrec/r200"), "slot keys: r99, then r100 to r199");
    RkPass e = mk("one-more.example", "u", "p"); check(rk_pw_save(&e, nullptr) == RK_E_FULL, "the 201st: full");
    uint8_t h = 0xEE, id34[34] = {1, 1}; check(rk_save("one-more.example", 16, &h, 1, "n", 1, "", 0, id34) == RK_E_FULL && rk_room("one-more.example", 16, &h, 1) == RK_E_FULL, "a passkey registration is refused too (passwords count toward 200)");
    rk_test_reboot();
    check(rk_count_all() == 200, "after a reboot all 200 reload (r100+ keys found)");
    RkPass o; g_vaultOpenLeft = 32;
    check(rk_pw_open(149, &o) == RK_OK && !strcmp(o.site, "site199.example"), "the last entry (slot 199) opens"); rk_pw_wipe(&o);
    RkAcct a; check(rk_at(49, &a) == RK_OK && !strcmp(a.site, "site196.example"), "the last passkey opens");
  }
  // ---- 4b. bulk delete (4 Nov 2026): one tombstone write; a merge of the old backup brings none back ----
  {
    rk_wipe_all(); g_vaultOpenLeft = 32;
    for (int i = 0; i < 160; i++) { char st[32]; snprintf(st, sizeof st, "bulk%03d.example", i); RkPass e = mk(st, "u", "p"); rk_pw_save(&e, nullptr); }
    static uint8_t old[VB_BLOB_MAX]; size_t on = 0; int nr = 0, nt = 0; uint32_t gen = 0;
    check(rk_export(old, VB_BLOB_MAX - VB_HDR, &on, &nr, &nt, &gen) == RK_OK && nr == 160, "bulk: the relay backup before the delete holds 160");
    int sl[145]; uint8_t ids[145][8];
    for (int i = 0; i < 145; i++) { sl[i] = rk_pw_slot_at(i); rk_pw_id_of(sl[i], ids[i]); }
    ids[3][0] ^= 1;                       // one item changed since the phone's list: skipped, not deleted
    int done = 0, skipped = 0;
    int r = rk_delete_many(sl, ids, 145, &done, &skipped);
    check(r == RK_OK && done == 144 && skipped == 1 && rk_pw_count() == 16, "bulk: 144 deleted, the changed one skipped, 16 left");
    static uint8_t now_[VB_BLOB_MAX]; size_t nn = 0; int nr2 = 0, nt2 = 0;
    rk_export(now_, VB_BLOB_MAX - VB_HDR, &nn, &nr2, &nt2, &gen);
    check(nt2 == 144, "bulk: 144 tombstones kept (the old cap of 128 would have dropped 16)");
    RkImport st{}; rk_import(old, on, &st);
    check(rk_pw_count() == 16 && st.added == 0, "bulk: merging the old relay backup brings none of the 144 back");
    // delete everything left, ids not checked (the KEY's Delete all)
    int all[RK_MAX], m = 0; for (int i = 0; i < rk_pw_count(); i++) all[m++] = rk_pw_slot_at(i);
    done = skipped = 0; r = rk_delete_many(all, nullptr, m, &done, &skipped);
    check(r == RK_OK && done == 16 && rk_pw_count() == 0, "delete all: the rest gone in one call");
    st = {}; rk_import(old, on, &st);
    check(rk_pw_count() == 0, "delete all: the old backup brings none of the 160 back (160 tombstones, under the cap of 256)");
    check(rk_delete_many(all, nullptr, 0, &done, &skipped) == RK_E_FORMAT, "bulk: an empty list is refused");
  }
  // ---- 4c. usernames book (4 Nov 2026) ----
  {
    rk_wipe_all(); rk_forget_cache();
    char ub[RK_UB_MAX][RK_PW_FIELD_MAX + 1];
    check(rk_ub_list(ub, RK_UB_MAX) == -1 && rk_ub_add("a@b.c") == RK_E_NOVAULT, "book: no index key, no list and no add");
    uint8_t K[32]; for (int i = 0; i < 32; i++) K[i] = (uint8_t)(0x41 + i);
    rk_idx_open(K, 7, rk_lock_epoch());
    check(rk_ub_list(ub, RK_UB_MAX) == 0, "book: empty at first");
    check(rk_ub_add("josh@example.com") == RK_OK && rk_ub_add("joshc") == RK_OK && rk_ub_add("josh@example.com") == RK_OK, "book: add, and a duplicate is not an error");
    int n = rk_ub_list(ub, RK_UB_MAX);
    check(n == 2 && !strcmp(ub[0], "joshc") && !strcmp(ub[1], "josh@example.com"), "book: two, newest first, no duplicate");
    bool plain = false; for (auto& kv : g_nvs) for (size_t i = 0; i + 5 <= kv.second.size(); i++) if (!memcmp(kv.second.data() + i, "joshc", 5)) plain = true;
    check(!plain, "book: no username readable in flash (sealed)");
    check(rk_ub_del(0) == RK_OK && rk_ub_list(ub, RK_UB_MAX) == 1 && !strcmp(ub[0], "josh@example.com"), "book: remove");
    for (int i = 0; i < RK_UB_MAX + 2; i++) { char u[24]; snprintf(u, sizeof u, "u%02d@x.io", i); rk_ub_add(u); }
    check(rk_ub_list(ub, RK_UB_MAX) == RK_UB_MAX && rk_ub_add("one-more") == RK_E_FULL, "book: 16 at most, then full");
    std::string longU(RK_PW_FIELD_MAX, 'l'); rk_ub_del(0);
    check(rk_ub_add(longU.c_str()) == RK_OK && rk_ub_list(ub, RK_UB_MAX) == RK_UB_MAX && strlen(ub[0]) == RK_PW_FIELD_MAX, "book: a 128-byte username round-trips");
    rk_forget_cache(); uint8_t K2[32]; memcpy(K2, K, 32); K2[0] ^= 1; rk_idx_open(K2, 7, rk_lock_epoch());
    check(rk_ub_list(ub, RK_UB_MAX) == 0, "book: another key reads nothing (starts empty)");
    rk_forget_cache(); rk_idx_open(K, 7, rk_lock_epoch());
    check(rk_ub_list(ub, RK_UB_MAX) == RK_UB_MAX, "book: the right key reads it again");
    rk_forget_cache();
  }
  // ---- 5. a full vault backs up and restores ----
  {
    rk_wipe_all(); g_vaultOpenLeft = 32;
    for (int i = 0; i < RK_MAX; i++) {   // every record at the largest size
      RkPass e; memset(&e, 0, sizeof e); e.slot = -1;
      snprintf(e.site, sizeof e.site, "%03d", i); memset(e.site + 3, 'x', 156); memset(e.user, 'u', 128); memset(e.pass, 'p', 128);
      rk_pw_save(&e, nullptr);
    }
    for (int i = 0; i < 128; i++) rk_delete(rk_pw_slot_at(0)), rk_pw_save([&]{ static RkPass e; memset(&e, 0, sizeof e); e.slot = -1; snprintf(e.site, sizeof e.site, "%03d", 200 + i); memset(e.site + 3, 'y', 156); memset(e.user, 'u', 128); memset(e.pass, 'q', 128); return &e; }(), nullptr);
    check(rk_count_all() == 200, "a full vault of largest-size records with 128 tombstones");
    static uint8_t body[VB_BLOB_MAX]; size_t bn = 0; int nr = 0, nt = 0; uint32_t gen = 0;
    int r = rk_export(body, VB_BLOB_MAX - VB_HDR, &bn, &nr, &nt, &gen);
    printf("INFO export %d, full body %zu bytes, base64 %zu, records %d tombstones %d\n", r, bn, ((bn + VB_HDR) + 2) / 3 * 4, nr, nt);
    check(r == RK_OK && nr == 200 && nt == 128 && bn == 102140, "export: 200 records + 128 tombstones = 102,140 bytes (fits VB_BLOB_MAX 128 KB)");
    check(((bn + VB_HDR) + 2) / 3 * 4 <= 160 * 1024 && ((bn + VB_HDR) + 2) / 3 * 4 < 160 * 1024 - 1024, "its base64 (about 136 KB) is under the relay's 160 KB and the ESP32 frame limit with room for the JSON");
    check(rk_export(body, 32 * 1024, &bn, &nr, &nt, &gen) == RK_E_SIZE, "the old 32 KB buffer would have refused it (why the cap moved)");
    rk_export(body, VB_BLOB_MAX - VB_HDR, &bn, &nr, &nt, &gen);
    rk_wipe_all();
    RkImport st{}; r = rk_import(body, bn, &st);
    check(r == RK_OK && st.added == 200 && st.full == 0 && st.foreign == 0 && rk_pw_count() == 200, "restore on a wiped KEY: all 200 come back, nothing counted as foreign or full");
    rk_test_reboot(); g_vaultOpenLeft = 32; RkPass o;
    check(rk_pw_open(199, &o) == RK_OK && strlen(o.pass) == 128, "a restored entry opens with the same words"); rk_pw_wipe(&o);
    // a backup of more than this KEY holds: counted as no room (the publish then stops)
    rk_wipe_all(); RkPass e = mk("local-only.example", "u", "p"); rk_pw_save(&e, nullptr);
    st = {}; rk_import(body, bn, &st);
    check(st.full == 1 && rk_count_all() == 200, "201 distinct records across the backup and this KEY: one counted as no room");
    // older firmware's view: a kind it does not hold is foreign (simulated with kind 9)
    std::vector<uint8_t> b9(body, body + bn); b9[2 + 2 + 12] = 9; rk_wipe_all(); st = {};
    rk_import(b9.data(), b9.size(), &st);
    check(st.foreign == 1 && st.added == 199, "a record of an unknown kind is still counted as foreign");
    // the old limit: more than 255 records in a body was refused; now up to 4 x RK_MAX parse
    std::vector<uint8_t> big; big.push_back(1); big.push_back(0x2C);   // 300 records
    for (int i = 0; i < 300; i++) { big.push_back(0); big.push_back(85); for (int k = 0; k < 85; k++) big.push_back((uint8_t)(k == 0 ? i >> 8 : k == 1 ? i : k == 8 ? 0x60 : (k == 9 || k == 10) ? 0 : k == 11 ? i : k == 12 ? 2 : i + k)); }
    big.push_back(0); big.push_back(0); rk_wipe_all(); st = {};
    check(rk_import(big.data(), big.size(), &st) == RK_OK && st.added == 200 && st.full == 100, "a 300-record body parses (was refused over 255); what does not fit is counted");
  }
  // ---- 6. v15 LABEL ----
  {
    extern bool g_v15; extern int g_labelUsed, g_labelCalls;
    rk_wipe_all(); g_vaultOpenLeft = 32; g_labelUsed = 0;
    pk("a.example", 1, "pk");
    for (int i = 0; i < 40; i++) { char s2[32], u[16]; snprintf(s2, sizeof s2, "site%02d.example", i); snprintf(u, sizeof u, "user%d", i); RkPass e = mk(s2, u, "secret-pass"); rk_pw_save(&e, nullptr); }
    rk_forget_cache(); g_vaultOpenLeft = 32; int o0 = g_vaultCalls[2], ok = 1; RkLabel L;
    for (int i = 0; i < 40; i++) { char s2[32], u[16]; snprintf(s2, sizeof s2, "site%02d.example", i); snprintf(u, sizeof u, "user%d", i);
      if (rk_pw_label(i, &L) || strcmp(L.site, s2) || strcmp(L.user, u)) ok = 0; }
    check(ok && g_vaultCalls[2] == o0 && g_vaultOpenLeft == 32, "40 entries listed by LABEL with the 32 OPENs untouched (more than one sitting's opens)");
    check(rk_label_left() == 360, "labels left reported from the G0 (360)");
    int c0 = g_labelCalls; for (int i = 0; i < 40; i++) rk_pw_label(i, &L);
    check(g_labelCalls == c0, "a second listing comes from the PSRAM cache: no LABEL spent");
    RkPass e; rk_pw_open(3, &e); e.slot = rk_pw_slot_at(3); strcpy(e.user, "renamed"); rk_pw_save(&e, nullptr); rk_pw_wipe(&e);
    c0 = g_labelCalls; rk_pw_label(3, &L);
    check(g_labelCalls == c0 + 1 && !strcmp(L.user, "renamed"), "an edited entry is labelled again (the cached label no longer matches its time)");
    rk_forget_cache(); c0 = g_labelCalls; rk_pw_label(0, &L);
    check(g_labelCalls == c0 + 1, "a lock drops the labels");
    g_labelUsed = 400; rk_forget_cache();
    check(rk_pw_label(1, &L) == RK_E_G0 && rk_last_res() == 0xEB && strstr(rk_hint(), "power cycle"), "the 401st LABEL this life: refused, the hint says power cycle");
    g_labelUsed = 0; g_v15 = false;
    check(rk_pw_label(1, &L) == RK_E_NOVAULT, "a G0 older than v15: labels unavailable (not a crash, not an OPEN)");
    g_v15 = true;
    // the 0xE3 hint
    s_lastRes = 0xE3; check(strstr(rk_hint(), "PASSKEY mode") != nullptr, "0xE3 names the cause: log in once in PASSKEY mode, or allow the NOSTR gate");
  }
  // ---- 7. most recent first (the PASSWORDS list order) ----
  {
    rk_wipe_all(); g_vaultOpenLeft = 32;
    const char* names[4] = {"a.example", "b.example", "c.example", "d.example"};
    for (int i = 0; i < 4; i++) { RkPass e = mk(names[i], "u", "p"); rk_pw_save(&e, nullptr); }
    pk("pk.example", 9, "x");
    int ord[8]; int n = rk_pw_order(ord, 8); RkPass o;
    bool ok = n == 4;
    const char* want[4] = {"d.example", "c.example", "b.example", "a.example"};
    for (int i = 0; i < n && ok; i++) { rk_pw_open(ord[i], &o); if (strcmp(o.site, want[i])) ok = false; rk_pw_wipe(&o); }
    check(ok, "order: newest first, passkeys left out");
    RkPass e = mk("b.example", "u", "changed"); rk_pw_save(&e, nullptr);   // b edited: now the newest
    n = rk_pw_order(ord, 8); rk_pw_open(ord[0], &o);
    check(n == 4 && !strcmp(o.site, "b.example"), "an edited entry moves to the top"); rk_pw_wipe(&o);
    check(rk_pw_order(ord, 2) == 2, "max respected");
  }
  // ---- 8. PWA work (3 Nov 2026): same-site matches by LABEL, index lookup, the import window ----
  {
    extern int g_labelUsed; extern bool g_impArmed, g_impUsed; extern int g_impCalls;
    rk_wipe_all(); g_vaultOpenLeft = 32; g_labelUsed = 0; rk_forget_cache();
    for (int i = 0; i < 6; i++) { char u[16]; snprintf(u, sizeof u, "user%d", i); RkPass e = mk("mail.example", u, "p"); check(rk_pw_save(&e, nullptr) == RK_OK, "same site, new username: saved"); }
    check(g_vaultOpenLeft == 32, "six accounts on one site cost no OPEN (the match runs on LABELs)");
    check(rk_pw_count() == 6, "six entries");
    RkPass e = mk("mail.example", "user3", "newpass"); int slot = -1; int before = g_vaultOpenLeft;
    check(rk_pw_save(&e, &slot) == RK_OK && rk_pw_count() == 6, "the same site and username replaces");
    check(before - g_vaultOpenLeft == 1, "a real match costs one OPEN (its created date)");
    RkLabel L, t; int i3 = -1; for (int i = 0; i < rk_pw_count(); i++) { rk_pw_label(i, &t); if (t.slot == slot) { i3 = i; L = t; } }
    check(i3 >= 0 && rk_pw_index_of(slot, L.id8) == i3, "index_of finds the entry by slot and id");
    uint8_t bad[8]; memcpy(bad, L.id8, 8); bad[0] ^= 1;
    check(rk_pw_index_of(slot, bad) == -1, "index_of: another id in that slot is not the entry the PWA named");
    { uint8_t got[8]; check(rk_pw_id_of(slot, got) && !memcmp(got, L.id8, 8) && !rk_pw_id_of(150, got), "id_of reads the id from the clear header (no G0 call)"); }
    check(rk_pw_index_of(150, L.id8) == -1 && rk_pw_index_of(-1, nullptr) == -1, "index_of: an empty or bad slot");
    int sl = 0, tl = 0;
    check(rk_pw_import_window(&sl, &tl) == RK_E_G0 && rk_last_res() == 0xEA, "import window refused without a right PIN just before");
    check(strstr(rk_hint(), "import window") != nullptr, "0xEA has a hint");
    g_impArmed = true; RkLabel L2; rk_forget_cache(); rk_pw_label(0, &L2);
    check(rk_pw_import_window(&sl, &tl) == RK_E_G0, "an op between the PIN and IMPORT spends the arm");
    g_impArmed = true;
    check(rk_pw_import_window(&sl, &tl) == RK_OK && sl == 300 && tl == 300, "import window opens: 300 SEALs, 300 TAGs");
    g_impArmed = true;
    check(rk_pw_import_window(&sl, &tl) == RK_E_G0 && rk_last_res() == 0xEA, "a second window in the same life is refused");
  }
  // ---- 9. P4-10 (3 Nov 2026): the sealed site index ----
  {
    extern int g_labelCalls, g_labelUsed;
    auto findBytes = [](const char* needle){ size_t n = strlen(needle); for (auto& kv : g_nvs) { auto& v = kv.second; for (size_t i = 0; i + n <= v.size(); i++) if (!memcmp(v.data() + i, needle, n)) return true; } return false; };
    auto ixBlob = [](){ for (auto& kv : g_nvs) if (kv.first.size() >= 3 && kv.first.compare(kv.first.size() - 3, 3, "six") == 0) return kv.second; return std::vector<uint8_t>(); };
    rk_wipe_all(); g_vaultOpenLeft = 32; g_labelUsed = 0; rk_forget_cache();
    uint8_t K[32]; for (int i = 0; i < 32; i++) K[i] = (uint8_t)(0xA0 + i);
    check(rk_idx_open(K, 7, rk_lock_epoch()) == 0 && rk_idx_have_key(), "index: opens with no blob yet (0 names)");
    const char* sites[5] = {"github.com", "mail.example", "New entry 4", "zz.example", "bank.example"};
    for (int i = 0; i < 5; i++) { RkPass e = mk(sites[i], "u", "pw-secret-1"); check(rk_pw_save(&e, nullptr) == RK_OK, "index: save"); }
    std::string longSite(120, 'x'); longSite += ".example";
    { RkPass e = mk(longSite.c_str(), "u", "p"); rk_pw_save(&e, nullptr); }
    check(ixBlob().size() > 0, "index: written by the saves");
    check(!findBytes("github.com") && !findBytes("mail.example") && !findBytes("pw-secret-1"), "flash dump: no site name or password in the clear anywhere in nvs_vault");
    // a restart: everything from RAM gone, the same key back
    rk_test_reboot(); rk_forget_cache(); check(!rk_idx_have_key(), "lock wipes the index key");
    int calls0 = g_labelCalls;
    check(rk_idx_open(K, 7, rk_lock_epoch()) == 6, "unlock: all 6 names from the index");
    bool all = true; char nm[80]; bool pend = false, cut = false; int pendings = 0, cuts = 0;
    for (int i = 0; i < rk_pw_count(); i++) { if (!rk_pw_site(i, nm, sizeof nm, &pend, &cut)) all = false; pendings += pend; cuts += cut; }
    check(all && g_labelCalls == calls0, "every name known with no LABEL (no G0 call)");
    check(pendings == 1 && cuts == 1, "flags: one pending (New entry 4), one cut (the 128-byte site)");
    { int i = -1; for (int k = 0; k < rk_pw_count(); k++) { rk_pw_site(k, nm, sizeof nm, nullptr, &cut); if (cut) i = k; }
      RkLabel L; rk_pw_label(i, &L); rk_pw_site(i, nm, sizeof nm, nullptr, &cut);
      check(strlen(L.site) == longSite.size() && !cut, "a cut name: the label gives the full one and replaces it"); }
    // wrong key, wrong generation, an altered blob: no names, rebuilt from labels
    rk_forget_cache(); uint8_t K2[32]; memcpy(K2, K, 32); K2[0] ^= 1;
    check(rk_idx_open(K2, 7, rk_lock_epoch()) == 0 && !rk_pw_site_known(0), "another key: nothing opens");
    rk_forget_cache(); check(rk_idx_open(K, 8, rk_lock_epoch()) == 0, "another SE generation (an earlier setup): refused");
    rk_forget_cache();
    for (auto& kv : g_nvs) if (kv.first.size() >= 3 && kv.first.compare(kv.first.size() - 3, 3, "six") == 0) kv.second[20] ^= 0x40;
    check(rk_idx_open(K, 7, rk_lock_epoch()) == 0, "an altered blob: refused (GCM)");
    for (int i = 0; i < rk_pw_count(); i++) { RkLabel L; rk_pw_label(i, &L); }   // the background reader heals it
    rk_idx_flush(); rk_forget_cache();
    check(rk_idx_open(K, 7, rk_lock_epoch()) == 6, "healed by labels: all 6 back after the next unlock");
    // an edit and a delete follow
    { int i = -1; for (int k = 0; k < rk_pw_count(); k++) { rk_pw_site(k, nm, sizeof nm, nullptr, nullptr); if (!strcmp(nm, "zz.example")) i = k; }
      RkPass e = mk("aa.example", "u", "p"); e.slot = rk_pw_slot_at(i); rk_pw_save(&e, nullptr); }
    rk_delete(rk_pw_slot_at(0));
    rk_forget_cache(); int got = rk_idx_open(K, 7, rk_lock_epoch());
    bool hasAa = false, hasZz = false; for (int k = 0; k < rk_pw_count(); k++) { if (rk_pw_site(k, nm, sizeof nm, nullptr, nullptr)) { hasAa |= !strcmp(nm, "aa.example"); hasZz |= !strcmp(nm, "zz.example"); } }
    check(got == 5 && hasAa && !hasZz, "an edit and a delete are in the index after the next unlock");
    // a record written while the key was not in RAM (a restore, another life): out of step, then healed
    rk_forget_cache(); { RkPass e = mk("restored.example", "u", "p"); rk_pw_save(&e, nullptr); }
    rk_idx_open(K, 7, rk_lock_epoch());
    int unknown = 0; for (int k = 0; k < rk_pw_count(); k++) unknown += !rk_pw_site_known(k);
    check(unknown == 1, "a record written while locked: the only name not known");
    for (int k = 0; k < rk_pw_count(); k++) if (!rk_pw_site_known(k)) { RkLabel L; rk_pw_label(k, &L); }
    rk_idx_flush(); rk_forget_cache(); check(rk_idx_open(K, 7, rk_lock_epoch()) == 6, "healed once, then known");
    // an import batches the writes
    auto before = ixBlob(); rk_idx_batch(true);
    for (int i = 0; i < 3; i++) { char st[32]; snprintf(st, sizeof st, "imp%d.example", i); RkPass e = mk(st, "u", "p"); rk_pw_save(&e, nullptr); }
    check(ixBlob() == before, "import batch: no index write per entry");
    rk_idx_batch(false); check(ixBlob() != before, "batch off: written once");
    rk_forget_cache(); check(rk_idx_open(K, 7, rk_lock_epoch()) == 9, "the imported names are there");
    // the wraps
    uint8_t w[RK_IDX_WRAP], r[RK_IDX_WRAP]; for (int i = 0; i < (int)RK_IDX_WRAP; i++) w[i] = (uint8_t)i;
    check(!rk_idx_wrap_get('N', r) && rk_idx_wrap_put('N', w) && rk_idx_wrap_get('N', r) && !memcmp(w, r, RK_IDX_WRAP), "wrap N: put and get");
    rk_idx_wrap_del('N'); check(!rk_idx_wrap_get('N', r), "wrap N: deleted (the gate closed)");
    check(rk_idx_wrap_put('P', w) && rk_idx_wrap_get('P', r), "wrap P kept apart from N");
    // 200 entries fit
    rk_wipe_all(); g_vaultOpenLeft = 32; rk_forget_cache(); rk_idx_open(K, 7, rk_lock_epoch()); rk_idx_batch(true);
    for (int i = 0; i < RK_MAX; i++) { char st[200]; snprintf(st, sizeof st, "%03d-%s", i, std::string(190, 'y').c_str()); RkPass e = mk(st, "", "p"); rk_pw_save(&e, nullptr); }
    rk_idx_batch(false);
    size_t bl = ixBlob().size();
    rk_forget_cache(); int g200 = rk_idx_open(K, 7, rk_lock_epoch());
    printf("      (index blob with 200 entries of 194-byte names: %zu bytes)\n", bl);
    check(g200 == RK_MAX && bl > 0 && bl <= 12 + 3 + RK_MAX * (23 + RK_IDX_SITE) + 16, "200 entries with long names: all in, blob within its bound");
    // 3 Nov 2026: the seal now runs GCM in 512-byte pieces (the one-shot call failed on
    // the KEY past ~2 KB). Same format: a chunked blob opens one-shot and back.
    {
      extern int g_gcmFailAt;
      std::vector<uint8_t> B = ixBlob(); size_t cl = B.size() - 28; std::vector<uint8_t> pt(cl);
      uint8_t aad[16]; memcpy(aad, "FAVILLA-SIDX-v1", 15); aad[15] = 7;
      mbedtls_gcm_context g; mbedtls_gcm_init(&g); mbedtls_gcm_setkey(&g, MBEDTLS_CIPHER_ID_AES, K, 256);
      bool one = mbedtls_gcm_auth_decrypt(&g, cl, B.data(), 12, aad, 16, B.data() + 12 + cl, 16, B.data() + 12, pt.data()) == 0;
      check(one && cl > 2048 && pt[0] == 2 && ((pt[1] << 8) | pt[2]) == RK_MAX, "chunked seal: the one-shot GCM opens it (format unchanged)");
      std::vector<uint8_t> O(B.size()); memcpy(O.data(), B.data(), 12);
      mbedtls_gcm_crypt_and_tag(&g, MBEDTLS_GCM_ENCRYPT, cl, O.data(), 12, aad, 16, pt.data(), O.data() + 12, 16, O.data() + 12 + cl);
      mbedtls_gcm_free(&g);
      check(O == B, "chunked seal: byte for byte the one-shot result");
      for (auto& kv : g_nvs) if (kv.first.size() >= 3 && kv.first.compare(kv.first.size() - 3, 3, "six") == 0) kv.second = O;
      rk_forget_cache(); check(rk_idx_open(K, 7, rk_lock_epoch()) == RK_MAX, "a blob sealed the old way opens with the chunked code");
      // the engine fails mid-way: no crash, the old blob stays, names fall back to labels
      std::vector<uint8_t> before = ixBlob();
      { RkRow rw; g_gcmFailAt = 3; if (rk_pw_row(0, &rw)) rk_delete(rw.slot); g_gcmFailAt = 0; }   // the delete's own write fails
      check(ixBlob() == before, "seal fails in a middle piece: the last good blob is kept");
      rk_idx_flush(); check(ixBlob() != before, "next flush: written");
      rk_forget_cache(); g_gcmFailAt = 2; int gf = rk_idx_open(K, 7, rk_lock_epoch()); g_gcmFailAt = 0;
      check(gf == 0 && rk_idx_have_key(), "open fails in a middle piece: key kept, names come back by label");
      rk_forget_cache(); check(rk_idx_open(K, 7, rk_lock_epoch()) == RK_MAX - 1, "and the next open reads them all");
    }
    rk_wipe_all(); rk_forget_cache(); check(!rk_idx_wrap_get('P', r) && ixBlob().empty(), "wallet wipe: the index and the wraps are gone");
  }
  // ---- 10. P4-10 review fixes (3 Nov 2026) ----
  {
    extern int g_nvsFree;
    auto ixBlob = [](){ for (auto& kv : g_nvs) if (kv.first.size() >= 3 && kv.first.compare(kv.first.size() - 3, 3, "six") == 0) return kv.second; return std::vector<uint8_t>(); };
    rk_wipe_all(); g_vaultOpenLeft = 32; rk_forget_cache();
    uint8_t K[32]; for (int i = 0; i < 32; i++) K[i] = (uint8_t)(0x30 + i);
    rk_idx_open(K, 7, rk_lock_epoch());
    for (int i = 0; i < 4; i++) { char st[32]; snprintf(st, sizeof st, "r%d.example", i); RkPass e = mk(st, "user", "p"); rk_pw_save(&e, nullptr); }
    // (3) a lock between the unwrap and the open: the key is refused
    uint32_t ep = rk_lock_epoch(); rk_forget_cache();
    check(rk_idx_open(K, 7, ep) == -1 && !rk_idx_have_key(), "(3) a lock after the unwrap: the key is not installed");
    // (1) one locked row read: slot, id, name and user of the same record
    rk_idx_open(K, 7, rk_lock_epoch()); RkRow row; RkLabel L;
    bool same = true;
    for (int i = 0; i < rk_pw_count(); i++) { rk_pw_label(i, &L); if (!rk_pw_row(i, &row) || row.slot != L.slot || memcmp(row.id8, L.id8, 8) || strcmp(row.site, L.site) || !row.userKnown || strcmp(row.user, L.user)) same = false; }
    check(same, "(1) a row is one record: slot, id, name and username agree");
    rk_forget_cache(); rk_idx_open(K, 7, rk_lock_epoch());
    check(rk_pw_row(0, &row) && !row.userKnown && row.site[0], "(1) from the index alone: name known, username not (null to the phone)");
    rk_forget_cache(); { RkPass e = mk("unindexed.example", "u", "p"); rk_pw_save(&e, nullptr); } rk_idx_open(K, 7, rk_lock_epoch());
    { bool listedUnknown = false; for (int i = 0; i < rk_pw_count(); i++) { if (rk_pw_row(i, &row) && !row.nameKnown && row.slot >= 0) listedUnknown = true; }
      check(listedUnknown, "a record whose name is not known yet is still a row (slot and id), never left out"); }
    { static RkRow rows[RK_MAX]; int n = rk_pw_rows(rows, RK_MAX); int ord[RK_MAX]; int m = rk_pw_order(ord, RK_MAX); bool same = n == m;
      for (int k = 0; k < n && same; k++) { RkRow r1; rk_pw_row(ord[k], &r1); same = r1.slot == rows[k].slot && !memcmp(r1.id8, rows[k].id8, 8) && r1.nameKnown == rows[k].nameKnown && !strcmp(r1.site, rows[k].site); }
      check(same, "rk_pw_rows (one lock) gives the same rows, newest first, as row by row"); }
    // (2) a restore that rewrites a record keeps no old name: export, change one entry
    // to another site with the SAME id and updated (the tie case), import
    {
      static uint8_t body[200000]; size_t bn = 0; int nr = 0, nt = 0; uint32_t gen = 0;
      check(rk_export(body, sizeof body, &bn, &nr, &nt, &gen) == RK_OK, "(2) export");
      int s0 = rk_pw_slot_at(0); RkLabel L0; rk_pw_label(0, &L0);
      // forge the tie: a record with L0's id and updated but another site, sealed by the model G0
      // the tie is decided by the sealed bytes, and the site tag comes first after id and time,
      // so try other site names until one wins the tie
      static char other[40]; RkImport st{}; size_t res = 0;
      for (int t = 0; t < 64 && !st.added; t++) {
        snprintf(other, sizeof other, "other%d.example", t);
        uint8_t pt[300]; size_t p = 0; memcpy(pt, L0.id8, 8); wr32(pt + 8, L0.updated); pt[12] = RK_KIND_PASSWORD; p = 13;
        pt[p++] = (uint8_t)strlen(other); memcpy(pt + p, other, strlen(other)); p += strlen(other);
        pt[p++] = 1; pt[p++] = 'u'; pt[p++] = 1; pt[p++] = 'x'; pt[p++] = 0; memset(pt + p, 0, 12); p += 12;
        uint8_t sealed[600]; size_t sl = 0; uint8_t r8 = 0, left = 0;
        g0_vault(G0_VAULT_SEAL, pt, p, sealed, &sl, &r8, &left);
        uint8_t b2[2000]; size_t q = 0; b2[q++] = 0; b2[q++] = 1; b2[q++] = (uint8_t)(sl >> 8); b2[q++] = (uint8_t)sl; memcpy(b2 + q, sealed, sl); q += sl; b2[q++] = 0; b2[q++] = 0;
        st = {}; rk_import(b2, q, &st);
      }
      char nm[80]; bool known = rk_pw_site(0, nm, sizeof nm, nullptr, nullptr); (void)res; (void)s0;
      bool ok = st.added && (!known || !strcmp(nm, other));
      printf("      (restore tie: added %d same %d)\n", st.added, st.same);
      check(ok, "(2) a restore tie: the index never shows the old name for new bytes");
      // the tag binds too: a header whose tag no longer matches is not trusted
    }
    // (4) check value
    uint8_t kc[16]; rk_idx_kcv(K, kc);
    uint8_t K3[32]; memcpy(K3, K, 32); K3[5] ^= 1;
    check(rk_idx_kcv_ok(K, kc) && !rk_idx_kcv_ok(K3, kc), "(4) the check value accepts K_IDX and refuses anything else");
    // (8) an import writes every 10 entries
    rk_idx_flush(); rk_idx_batch(true); auto b0 = ixBlob();
    for (int i = 0; i < 9; i++) { char st[32]; snprintf(st, sizeof st, "b%d.example", i); RkPass e = mk(st, "u", "p"); rk_pw_save(&e, nullptr); }
    bool none9 = ixBlob() == b0;
    { RkPass e = mk("b9.example", "u", "p"); rk_pw_save(&e, nullptr); }
    check(none9 && ixBlob() != b0, "(8) an import: written at the 10th entry, not before");
    rk_idx_batch(false);
    // (8) a reopen during an import keeps the batch
    rk_idx_batch(true); rk_idx_open(K, 7, rk_lock_epoch()); auto b1 = ixBlob();
    { RkPass e = mk("c0.example", "u", "p"); rk_pw_save(&e, nullptr); }
    check(ixBlob() == b1, "(8) the batch survives a reopen"); rk_idx_batch(false);
    // (7) a full nvs_vault: records keep their room, the index waits
    auto b2v = ixBlob(); g_nvsFree = 40;
    { RkPass e = mk("d0.example", "u", "p"); check(rk_pw_save(&e, nullptr) == RK_OK, "(7) a save still works when nvs_vault is nearly full"); }
    check(ixBlob() == b2v, "(7) ...and the index is not written then (names fall back to labels)");
    g_nvsFree = 100000; rk_idx_flush(); check(ixBlob() != b2v, "(7) written once there is room");
  }
  printf("\n%s (%d passed, %d failed)\n", fail ? "SOME FAILED" : "ALL PASS", pass, fail);
  return fail ? 1 : 0;
}
