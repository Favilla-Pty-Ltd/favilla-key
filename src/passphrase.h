// ── passphrase.h — BIP-39 passphrase on the Favilla KEY ─────────────────────
// Included from main.cpp immediately before runRestoreFlow(), so every UI
// helper (spr, fSet/fEnd, uiAsk/uiCard/uiPanel, buttons, camera + qrScanOnce)
// is already declared. Nothing here is a header in the usual sense — it is a
// slice of main.cpp kept in its own file so the feature can be read in one
// place.
//
// What the passphrase IS on this device (rulings of 23 Sep 2026):
//   * accepted at RESTORE for interop with words+passphrase wallets
//     (Sparrow / Coldcard users), and offered at CREATE as an option AFTER the
//     word-verify quiz. The derived seed is sealed in the SE; the passphrase is
//     consumed and never stored, so day-to-day use never asks for it.
//   * entry by TYPING on the four buttons (entered twice) or by SCANNING a QR
//     made on favillakey.io/verify/passphrase (reviewed, not re-entered).
//   * ASCII printable only, no whitespace stripping (a trailing space is drawn
//     so the owner can see it), 100-character cap.
//   * a mandatory wallet-fingerprint screen after derivation on both paths.
//
// Everything is blocking + synchronous, like the rest of onboarding: these
// screens run before the device has a network, so nothing is starved.

#pragma once

// ── Card icons (25 Sep 2026) ────────────────────────────────────────────────
// 22x22, on the LEFT of the card so the icon is the first thing read on each
// row. Accent when selected, dim otherwise. The geometric ones (word list,
// keypad, QR) are crisp pixel primitives; the curved ones (arrow, tick, key,
// lock, door) are 4-bit anti-aliased masks rendered from vector drawings,
// blitted with the same blitA4() the home tiles use, so they get real edges
// instead of drawArc()'s stair-steps.
static const uint8_t PP_ICON_REDO_A4[242] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x14,0x55,0x41,0x00,0x00,0x24,0x00,
  0x00,0x00,0x00,0x4A,0xEF,0xFF,0xFE,0xA4,0x00,0xCF,0x40,
  0x00,0x00,0x08,0xFF,0xFE,0xCC,0xEF,0xFF,0xA1,0xCE,0x50,
  0x00,0x00,0xAF,0xFB,0x51,0x00,0x15,0xAF,0xFD,0xDF,0x50,
  0x00,0x09,0xFF,0x70,0x00,0x00,0x00,0x05,0xDF,0xEF,0x50,
  0x00,0x3F,0xF7,0x00,0x00,0x00,0x02,0xBA,0xDE,0xEE,0x50,
  0x00,0xAE,0xB0,0x00,0x00,0x00,0x06,0xFF,0xFF,0xFF,0x50,
  0x01,0xEF,0x50,0x00,0x00,0x00,0x00,0x67,0x77,0x76,0x00,
  0x04,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x05,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xAE,0x30,
  0x05,0xFC,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xDF,0x50,
  0x04,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x01,0xEF,0x40,
  0x01,0xEF,0x50,0x00,0x00,0x00,0x00,0x00,0x05,0xFE,0x10,
  0x00,0xAE,0xB0,0x00,0x00,0x00,0x00,0x00,0x0B,0xEA,0x00,
  0x00,0x3F,0xF7,0x00,0x00,0x00,0x00,0x00,0x7F,0xF3,0x00,
  0x00,0x09,0xFF,0x70,0x00,0x00,0x00,0x07,0xFF,0x80,0x00,
  0x00,0x00,0xAF,0xFB,0x51,0x00,0x15,0xBF,0xFA,0x00,0x00,
  0x00,0x00,0x08,0xFF,0xFE,0xCC,0xEF,0xFF,0x80,0x00,0x00,
  0x00,0x00,0x00,0x3A,0xEF,0xFF,0xFE,0xA3,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x14,0x55,0x41,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
static const uint8_t PP_ICON_TICK_A4[242] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0x50,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4F,0xF8,0x10,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xDE,0xEE,0x20,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0A,0xFE,0xF5,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x6F,0xEF,0x90,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x03,0xEE,0xEC,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x0C,0xFE,0xE3,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xEF,0x70,0x00,0x00,
  0x00,0x05,0x90,0x00,0x00,0x04,0xFE,0xFB,0x00,0x00,0x00,
  0x00,0x5E,0xF9,0x00,0x00,0x1D,0xEE,0xE1,0x00,0x00,0x00,
  0x00,0x9F,0xEF,0x90,0x00,0xAF,0xEF,0x50,0x00,0x00,0x00,
  0x00,0x09,0xFE,0xFA,0x06,0xFE,0xF9,0x00,0x00,0x00,0x00,
  0x00,0x00,0x9F,0xEF,0xBE,0xEE,0xC0,0x00,0x00,0x00,0x00,
  0x00,0x00,0x09,0xFE,0xFF,0xEE,0x30,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x9F,0xEE,0xF7,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x09,0xFF,0xB0,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x78,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00
};
static const uint8_t PP_ICON_KEY_A4[242] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x24,0x53,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x4B,0xEF,0xFF,0xD8,0x00,0x00,
  0x00,0x00,0x00,0x00,0x07,0xFF,0xFD,0xDE,0xFF,0xC2,0x00,
  0x00,0x00,0x00,0x00,0x6F,0xFB,0x41,0x12,0x7E,0xFC,0x00,
  0x00,0x00,0x00,0x01,0xEF,0xA0,0x00,0x00,0x04,0xEF,0x80,
  0x00,0x00,0x00,0x07,0xFD,0x10,0x00,0x89,0x20,0x7E,0xD0,
  0x00,0x00,0x00,0x0A,0xE8,0x00,0x06,0xDB,0xA0,0x2E,0xF3,
  0x00,0x00,0x00,0x0C,0xF6,0x00,0x05,0xDD,0x80,0x0D,0xE5,
  0x00,0x00,0x00,0x0B,0xF7,0x00,0x00,0x56,0x00,0x1D,0xF5,
  0x00,0x00,0x00,0x0C,0xEB,0x00,0x00,0x00,0x00,0x4F,0xE2,
  0x00,0x00,0x00,0xAF,0xF6,0x00,0x00,0x00,0x00,0xBE,0xB0,
  0x00,0x00,0x0A,0xFF,0x60,0x00,0x00,0x00,0x1A,0xFF,0x40,
  0x00,0x00,0xAF,0xF6,0x00,0x06,0xA7,0x69,0xDF,0xF7,0x00,
  0x00,0x0A,0xFF,0x60,0x05,0x9F,0xFF,0xFF,0xFE,0x60,0x00,
  0x00,0xAF,0xF6,0x00,0x9F,0xFF,0xCB,0xCA,0x71,0x00,0x00,
  0x0A,0xFF,0x60,0x00,0xDE,0xC7,0x00,0x00,0x00,0x00,0x00,
  0x3F,0xE7,0x00,0x7B,0xEF,0x40,0x00,0x00,0x00,0x00,0x00,
  0x5E,0xD0,0x07,0xFF,0xFD,0x10,0x00,0x00,0x00,0x00,0x00,
  0x5E,0xD1,0x0B,0xEB,0x72,0x00,0x00,0x00,0x00,0x00,0x00,
  0x4F,0xED,0xDE,0xF7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x0B,0xFF,0xFF,0xD2,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x45,0x54,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
static const uint8_t PP_ICON_LOCK_A4[242] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x29,0xDD,0xA3,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x03,0xEF,0xFF,0xFF,0x50,0x00,0x00,0x00,
  0x00,0x00,0x00,0x1D,0xFD,0x76,0xCF,0xE2,0x00,0x00,0x00,
  0x00,0x00,0x00,0x7F,0xE2,0x00,0x1D,0xF9,0x00,0x00,0x00,
  0x00,0x00,0x00,0xCE,0x90,0x00,0x07,0xED,0x00,0x00,0x00,
  0x00,0x00,0x00,0xDF,0x70,0x00,0x07,0xFE,0x20,0x00,0x00,
  0x00,0x00,0x01,0xDF,0x70,0x00,0x07,0xFE,0x20,0x00,0x00,
  0x00,0x00,0x00,0xDF,0x60,0x00,0x06,0xFE,0x10,0x00,0x00,
  0x00,0x00,0x37,0xEF,0xB7,0x77,0x7B,0xFE,0x84,0x00,0x00,
  0x00,0x06,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x70,0x00,
  0x00,0x0D,0xEE,0xFF,0xEE,0xEE,0xEE,0xFF,0xEE,0xE1,0x00,
  0x00,0x1E,0xFE,0xFF,0xFF,0xFF,0xFF,0xFF,0xEF,0xF2,0x00,
  0x00,0x1D,0xFE,0xFF,0xFE,0x87,0xEF,0xEF,0xEF,0xE2,0x00,
  0x00,0x1E,0xFE,0xFE,0xFE,0x00,0xCF,0xEF,0xEF,0xF2,0x00,
  0x00,0x1E,0xFE,0xFE,0xFE,0x10,0xCF,0xEF,0xEF,0xF2,0x00,
  0x00,0x1E,0xFE,0xFE,0xFD,0x00,0xCF,0xEF,0xEF,0xF2,0x00,
  0x00,0x1D,0xFE,0xFE,0xFE,0x76,0xEF,0xEF,0xEF,0xE2,0x00,
  0x00,0x1E,0xEE,0xEF,0xEF,0xFF,0xFE,0xFE,0xEE,0xF2,0x00,
  0x00,0x0B,0xFE,0xFF,0xFF,0xEE,0xFF,0xFF,0xFF,0xD0,0x00,
  0x00,0x02,0xCE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEC,0x30,0x00,
  0x00,0x00,0x02,0x22,0x22,0x22,0x22,0x22,0x20,0x00,0x00
};
static const uint8_t PP_ICON_DOOR_A4[242] = {
  0x00,0x00,0x02,0x77,0x77,0x77,0x77,0x77,0x20,0x00,0x00,
  0x00,0x00,0x0C,0xFF,0xFF,0xFF,0xFF,0xFF,0xD1,0x00,0x00,
  0x00,0x00,0x1E,0xEA,0x99,0x99,0x99,0x9E,0xF2,0x00,0x00,
  0x00,0x00,0x1D,0xF1,0x00,0x00,0x00,0x0D,0xE2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x0D,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x05,0x7E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x5F,0xFF,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x6F,0xFF,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x07,0x8E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x0D,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x1E,0xF2,0x00,0x00,
  0x00,0x00,0x1E,0xF2,0x00,0x00,0x00,0x0E,0xF2,0x00,0x00,
  0x00,0x00,0x0D,0xF3,0x11,0x11,0x11,0x1E,0xF1,0x00,0x00,
  0x06,0x77,0x7E,0xED,0xDD,0xDD,0xDD,0xDE,0xE8,0x77,0x71,
  0x1F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF2,
  0x08,0x99,0x9A,0xAA,0xAA,0xAA,0xAA,0xAA,0xA9,0x99,0x91
};

// 32 px icons for the taller (84 px) cards - Lucide "dices" and "cpu", via
// tools/svg2a4.py at --stroke 2.2.
#define PP_ICON_DICE_W 32
#define PP_ICON_DICE_H 32
#define PP_ICON_DICE_ROWBYTES 16
static const uint8_t PP_ICON_DICE_A4[512] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x8B,0xA7,0x10,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4E,0xFF,0xFF,0xC2,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xEE,0xFF,0xFE,0xFD,0x20,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x4E,0xEF,0xC3,0x4D,0xFF,0xD2,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xEE,0xFC,0x10,0x02,0xDF,0xFD,0x20,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x4E,0xEF,0xC1,0x05,0x50,0x2D,0xFF,0xD2,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x01,0xEE,0xFC,0x10,0x5F,0xF5,0x02,0xDF,0xED,0x30,0x00,
  0x00,0x00,0x00,0x00,0x00,0x01,0xEF,0xC1,0x00,0x5F,0xF5,0x00,0x2D,0xFE,0xD3,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x36,0x10,0x00,0x05,0x50,0x00,0x02,0xDF,0xFD,0x10,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0x50,0x2D,0xEF,0x70,
  0x00,0x00,0x12,0x22,0x22,0x22,0x22,0x22,0x10,0x00,0x00,0x5F,0xF5,0x03,0xFE,0xB0,
  0x00,0x1A,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEB,0x30,0x00,0x5F,0xF5,0x03,0xFE,0xB0,
  0x01,0xCF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xE3,0x00,0x05,0x50,0x2D,0xEF,0x70,
  0x07,0xFE,0xEB,0xBB,0xBB,0xBB,0xBB,0xBB,0xDE,0xFB,0x00,0x00,0x02,0xDF,0xFD,0x10,
  0x0B,0xEF,0x40,0x00,0x00,0x00,0x00,0x00,0x1D,0xEE,0x10,0x00,0x2D,0xFE,0xE3,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x0B,0xFE,0x20,0x02,0xDF,0xEE,0x30,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x7B,0x30,0x0B,0xFE,0x20,0x2D,0xFE,0xE3,0x00,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x02,0xFF,0xC0,0x0B,0xFE,0x20,0x8F,0xFE,0x30,0x00,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0xBE,0x70,0x0B,0xFE,0x20,0x4E,0xD3,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x01,0x00,0x0B,0xFE,0x20,0x01,0x10,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x05,0x50,0x00,0x00,0x00,0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x5F,0xF5,0x00,0x00,0x00,0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x5F,0xF5,0x00,0x00,0x00,0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x05,0x50,0x00,0x00,0x00,0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,
  0x0A,0xEE,0x92,0x22,0x22,0x22,0x22,0x22,0x4E,0xEE,0x10,0x00,0x00,0x00,0x00,0x00,
  0x04,0xFE,0xFE,0xEE,0xEE,0xEE,0xEE,0xEE,0xFE,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x8F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xC1,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x04,0xAB,0xBB,0xBB,0xBB,0xBB,0xBB,0xA7,0x10,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
#define PP_ICON_CPU_W 32
#define PP_ICON_CPU_H 32
#define PP_ICON_CPU_ROWBYTES 16
static const uint8_t PP_ICON_CPU_A4[512] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x7B,0x30,0x00,0x1A,0xA1,0x00,0x03,0xB7,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x01,0xFF,0xB0,0x00,0x6F,0xF6,0x00,0x0B,0xFF,0x10,0x00,0x00,0x00,
  0x00,0x00,0x00,0x04,0xEE,0xC2,0x22,0x8E,0xE8,0x22,0x2C,0xEE,0x40,0x00,0x00,0x00,
  0x00,0x00,0x04,0xCE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEB,0x30,0x00,0x00,
  0x00,0x00,0x4F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xE3,0x00,0x00,
  0x00,0x00,0xCF,0xED,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xCB,0xDE,0xFB,0x00,0x00,
  0x00,0x14,0xEE,0xD1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1D,0xEE,0x31,0x00,
  0x07,0xEE,0xEF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0xFE,0xEE,0x70,
  0x0B,0xFF,0xEF,0xB0,0x00,0x5A,0xBB,0xBB,0xBB,0xBB,0xA4,0x00,0x0B,0xFE,0xFF,0xB0,
  0x03,0xBC,0xEF,0xB0,0x05,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x40,0x0B,0xFE,0xCB,0x30,
  0x00,0x02,0xEF,0xB0,0x0B,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xB0,0x0B,0xFE,0x20,0x00,
  0x00,0x02,0xEF,0xB0,0x0B,0xFE,0x42,0x22,0x22,0x24,0xEF,0xB0,0x0B,0xFE,0x20,0x00,
  0x00,0x01,0xEF,0xB0,0x0B,0xFE,0x10,0x00,0x00,0x01,0xEF,0xB0,0x0B,0xFE,0x10,0x00,
  0x01,0x68,0xEF,0xB0,0x0B,0xFE,0x20,0x00,0x00,0x02,0xEF,0xB0,0x0B,0xFE,0x86,0x10,
  0x0A,0xFF,0xEF,0xB0,0x0B,0xFE,0x20,0x00,0x00,0x02,0xEF,0xB0,0x0B,0xFE,0xFF,0xA0,
  0x0A,0xFF,0xEF,0xB0,0x0B,0xFE,0x20,0x00,0x00,0x02,0xEF,0xB0,0x0B,0xFE,0xFF,0xA0,
  0x01,0x68,0xEF,0xB0,0x0B,0xFE,0x20,0x00,0x00,0x02,0xEF,0xB0,0x0B,0xFE,0x86,0x10,
  0x00,0x01,0xEF,0xB0,0x0B,0xFE,0x10,0x00,0x00,0x01,0xEF,0xB0,0x0B,0xFE,0x10,0x00,
  0x00,0x02,0xEF,0xB0,0x0B,0xFE,0x42,0x22,0x22,0x24,0xEF,0xB0,0x0B,0xFE,0x20,0x00,
  0x00,0x02,0xEF,0xB0,0x0B,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xB0,0x0B,0xFE,0x20,0x00,
  0x03,0xBC,0xEF,0xB0,0x04,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x50,0x0B,0xFE,0xCB,0x30,
  0x0B,0xFF,0xEF,0xB0,0x00,0x4A,0xBB,0xBB,0xBB,0xBB,0xA5,0x00,0x0C,0xFE,0xFF,0xB0,
  0x07,0xEE,0xEF,0xB0,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x0B,0xFE,0xEE,0x70,
  0x00,0x13,0xEE,0xD1,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x1D,0xEE,0x41,0x00,
  0x00,0x00,0xBF,0xED,0xBC,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xCB,0xDE,0xFC,0x00,0x00,
  0x00,0x00,0x3E,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF4,0x00,0x00,
  0x00,0x00,0x03,0xBE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEC,0x40,0x00,0x00,
  0x00,0x00,0x00,0x04,0xEE,0xC2,0x22,0x8E,0xE8,0x22,0x2C,0xEE,0x40,0x00,0x00,0x00,
  0x00,0x00,0x00,0x01,0xFF,0xB0,0x00,0x6F,0xF6,0x00,0x0B,0xFF,0x10,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x7B,0x30,0x00,0x1A,0xA1,0x00,0x03,0xB7,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

#define PP_ICON_NEWWALLET_W 32
#define PP_ICON_NEWWALLET_H 32
#define PP_ICON_NEWWALLET_ROWBYTES 16
static const uint8_t PP_ICON_NEWWALLET_A4[512] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x05,0xAB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBA,0x50,0x00,
  0x00,0x9F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xF9,0x00,
  0x05,0xFE,0xFE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEF,0xEF,0x50,
  0x0A,0xEE,0x82,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x28,0xEE,0xA0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x42,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x24,0xEF,0xB0,
  0x0B,0xFE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEF,0xB0,
  0x0B,0xFE,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xEF,0xB0,
  0x0B,0xFE,0xCB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBC,0xEE,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xEF,0xA0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x48,0x20,
  0x0B,0xFE,0x20,0x19,0xBB,0xB7,0x00,0x00,0x00,0x00,0x00,0x00,0x7B,0x30,0x00,0x00,
  0x0B,0xFE,0x20,0x6F,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x02,0xFF,0xB0,0x00,0x00,
  0x0B,0xFE,0x20,0x3D,0xEE,0xEB,0x00,0x00,0x00,0x00,0x00,0x02,0xEE,0xB0,0x00,0x00,
  0x0B,0xFE,0x20,0x01,0x22,0x20,0x00,0x00,0x00,0x00,0x00,0x02,0xEF,0xB0,0x00,0x00,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7B,0xBC,0xFF,0xEB,0xBB,0x30,
  0x0B,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xFF,0xFF,0xFF,0xFF,0xFF,0xB0,
  0x0A,0xEE,0x82,0x22,0x22,0x22,0x22,0x22,0x20,0x00,0xBE,0xEE,0xFF,0xFE,0xEE,0x70,
  0x05,0xFE,0xFE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEB,0x00,0x02,0x24,0xEF,0xC2,0x22,0x00,
  0x00,0x9F,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0x20,0x00,0x01,0xEE,0xB0,0x00,0x00,
  0x00,0x05,0xAB,0xBB,0xBB,0xBB,0xBB,0xBB,0xB7,0x00,0x00,0x02,0xFF,0xC0,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xBE,0x70,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
#define PP_ICON_RESTORE_W 32
#define PP_ICON_RESTORE_H 32
#define PP_ICON_RESTORE_ROWBYTES 16
static const uint8_t PP_ICON_RESTORE_A4[512] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x13,0x56,0x65,0x31,0x00,0x00,0x00,0x05,0x50,0x00,
  0x00,0x00,0x00,0x00,0x00,0x4A,0xDF,0xFF,0xFF,0xFD,0xA5,0x00,0x00,0x5F,0xF5,0x00,
  0x00,0x00,0x00,0x00,0x3B,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xC5,0x00,0x7E,0xE7,0x00,
  0x00,0x00,0x00,0x06,0xEF,0xFF,0xEB,0x87,0x78,0xBE,0xFF,0xFF,0x90,0x6F,0xF7,0x00,
  0x00,0x00,0x00,0x7F,0xEF,0xD7,0x10,0x00,0x00,0x01,0x6C,0xFE,0xFA,0x8F,0xF7,0x00,
  0x00,0x00,0x06,0xFE,0xFA,0x10,0x00,0x00,0x00,0x00,0x00,0x7F,0xEF,0xFE,0xF7,0x00,
  0x00,0x00,0x3E,0xEF,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xDE,0xEE,0xF7,0x00,
  0x00,0x00,0xBF,0xFA,0x00,0x00,0x00,0x00,0x00,0x00,0x7B,0xBB,0xDF,0xEE,0xE7,0x00,
  0x00,0x04,0xFE,0xD1,0x00,0x00,0x00,0x00,0x00,0x02,0xFF,0xFF,0xFF,0xFE,0xF7,0x00,
  0x00,0x0A,0xEF,0x70,0x00,0x00,0x00,0x00,0x00,0x00,0xBE,0xEE,0xFF,0xEE,0xE3,0x00,
  0x00,0x1E,0xFE,0x10,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x22,0x22,0x22,0x10,0x00,
  0x00,0x3F,0xFB,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x5E,0xF8,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x05,0x50,0x00,
  0x00,0x7E,0xE7,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x5F,0xF5,0x00,
  0x00,0x5F,0xF5,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x7E,0xE7,0x00,
  0x00,0x05,0x50,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x8F,0xF5,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xBF,0xF3,0x00,
  0x00,0x01,0x22,0x22,0x22,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0xEF,0xE1,0x00,
  0x00,0x3E,0xEE,0xFF,0xEE,0xEB,0x00,0x00,0x00,0x00,0x00,0x00,0x07,0xFE,0xA0,0x00,
  0x00,0x7F,0xEF,0xFF,0xFF,0xFF,0x20,0x00,0x00,0x00,0x00,0x00,0x1D,0xEF,0x40,0x00,
  0x00,0x7E,0xEE,0xFD,0xBB,0xB7,0x00,0x00,0x00,0x00,0x00,0x00,0xAF,0xFB,0x00,0x00,
  0x00,0x7F,0xEE,0xED,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x08,0xFE,0xE3,0x00,0x00,
  0x00,0x7F,0xEF,0xFE,0xF7,0x00,0x00,0x00,0x00,0x00,0x01,0xAF,0xEF,0x60,0x00,0x00,
  0x00,0x7F,0xF8,0xAF,0xEF,0xC6,0x10,0x00,0x00,0x01,0x7D,0xFE,0xF7,0x00,0x00,0x00,
  0x00,0x7F,0xF6,0x09,0xFF,0xFF,0xEB,0x87,0x78,0xBE,0xFF,0xFE,0x60,0x00,0x00,0x00,
  0x00,0x7E,0xE7,0x00,0x5C,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xB3,0x00,0x00,0x00,0x00,
  0x00,0x5F,0xF5,0x00,0x00,0x5A,0xDF,0xFF,0xFF,0xFD,0xA4,0x00,0x00,0x00,0x00,0x00,
  0x00,0x05,0x50,0x00,0x00,0x00,0x13,0x56,0x65,0x31,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

static void ppIconNewWallet32(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_NEWWALLET_A4, 32, 32, 16, x + 16, y + 16, c, bg); }
static void ppIconRestore32  (int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_RESTORE_A4,   32, 32, 16, x + 16, y + 16, c, bg); }
// The product's own Nostr (39 px) and Bitcoin (33 px) marks, centred in the
// 32 px icon column - same artwork as the home tiles and the two-door fork.
static void ppIconNostr32(int x, int y, uint16_t c, uint16_t bg){ drawNostrLogo(x + 16, y + 16, c, bg); }
static void ppIconBtc32  (int x, int y, uint16_t c, uint16_t bg){ drawBtcLogo(x + 16, y + 16, c, bg); }
// 12 vs 24 words: the same word-list glyph at 32 px, short (3 lines) for 12
// and long (6 lines) for 24 - length is the thing that differs.
static void ppIconWords12_32(int x, int y, uint16_t c, uint16_t){
  const int ly[3] = {7, 15, 23}, ln[3] = {20, 14, 22};
  for(int i = 0; i < 3; i++){ spr.fillRect(x + 2, y + ly[i], 4, 4, c); spr.fillRect(x + 10, y + ly[i] + 1, ln[i], 2, c); }
}
static void ppIconWords24_32(int x, int y, uint16_t c, uint16_t){
  const int ly[6] = {2, 7, 12, 17, 22, 27}, ln[6] = {20, 14, 22, 16, 20, 12};
  for(int i = 0; i < 6; i++){ spr.fillRect(x + 2, y + ly[i], 3, 3, c); spr.fillRect(x + 9, y + ly[i] + 1, ln[i], 1, c); }
}
#define PP_ICON_CAMERA_W 32
#define PP_ICON_CAMERA_H 32
#define PP_ICON_CAMERA_ROWBYTES 16
static const uint8_t PP_ICON_CAMERA_A4[512] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x12,0x22,0x22,0x21,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x1A,0xEE,0xEE,0xEE,0xEE,0xA1,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x01,0xCF,0xFF,0xFF,0xFF,0xFF,0xFC,0x10,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x08,0xFE,0xEB,0xBB,0xBB,0xBE,0xEF,0x80,0x00,0x00,0x00,0x00,
  0x00,0x00,0x12,0x22,0x4E,0xEF,0x40,0x00,0x00,0x04,0xFE,0xE4,0x22,0x21,0x00,0x00,
  0x00,0x1A,0xEE,0xEE,0xFE,0xFA,0x00,0x00,0x00,0x00,0xAF,0xEF,0xEE,0xEE,0xA1,0x00,
  0x01,0xCF,0xFF,0xFF,0xFF,0xC1,0x00,0x00,0x00,0x00,0x1C,0xFF,0xFF,0xFF,0xFC,0x10,
  0x07,0xFE,0xEB,0xBB,0xB7,0x10,0x00,0x00,0x00,0x00,0x01,0x7B,0xBB,0xBE,0xEF,0x70,
  0x0B,0xEF,0x40,0x00,0x00,0x00,0x00,0x02,0x20,0x00,0x00,0x00,0x00,0x04,0xFE,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x07,0xCE,0xEC,0x70,0x00,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x01,0xBF,0xFF,0xFF,0xFB,0x10,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x09,0xFE,0xFC,0xCF,0xEF,0x90,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x2F,0xEE,0x50,0x05,0xEE,0xE2,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x6F,0xF9,0x00,0x00,0x9F,0xF6,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x6E,0xF6,0x00,0x00,0x6F,0xE6,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x5F,0xFB,0x00,0x00,0xBF,0xF5,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x1E,0xEF,0x93,0x39,0xFE,0xE1,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x06,0xFE,0xFF,0xFF,0xEF,0x60,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x7F,0xFF,0xFF,0xF7,0x00,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x03,0x8B,0xB8,0x30,0x00,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xFE,0x20,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0xEF,0xB0,
  0x0B,0xEF,0x40,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x04,0xFE,0xB0,
  0x07,0xFE,0xEB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBB,0xBE,0xEF,0x70,
  0x01,0xCF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFC,0x10,
  0x00,0x1A,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xEE,0xA1,0x00,
  0x00,0x00,0x12,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x22,0x21,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
#define PP_ICON_APERTURE_W 32
#define PP_ICON_APERTURE_H 32
#define PP_ICON_APERTURE_ROWBYTES 16
static const uint8_t PP_ICON_APERTURE_A4[512] = {
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x36,0x89,0x98,0x63,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x02,0x8D,0xFF,0xFF,0xFF,0xFF,0xD8,0x20,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x01,0x8E,0xFF,0xFF,0xEE,0xEE,0xFF,0xFF,0xE8,0x10,0x00,0x00,0x00,
  0x00,0x00,0x00,0x3C,0xFF,0xFC,0x74,0x3E,0xED,0x47,0xCF,0xFF,0xC3,0x00,0x00,0x00,
  0x00,0x00,0x04,0xEF,0xFC,0x50,0x00,0x9F,0xF6,0x00,0x05,0xCF,0xFE,0x40,0x00,0x00,
  0x00,0x00,0x3E,0xFF,0x90,0x00,0x03,0xFE,0xC0,0x00,0x00,0x09,0xFE,0xE3,0x00,0x00,
  0x00,0x01,0xDF,0xE7,0x00,0x00,0x0B,0xFF,0x40,0x00,0x00,0x00,0x8F,0xFD,0x10,0x00,
  0x00,0x09,0xFE,0xE1,0x00,0x00,0x5F,0xF9,0x00,0x00,0x00,0x00,0x08,0xEF,0x90,0x00,
  0x00,0x2E,0xEE,0xF9,0x00,0x00,0xDE,0xEB,0x99,0xAA,0x99,0x99,0x9A,0xEE,0xE2,0x00,
  0x00,0x9F,0xEE,0xEE,0x30,0x07,0xFE,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFE,0xF9,0x00,
  0x00,0xDF,0xB4,0xFE,0xB0,0x2E,0xEE,0xED,0xDD,0xEE,0xED,0xDD,0xDD,0xEE,0xFD,0x00,
  0x03,0xFF,0x70,0xBF,0xF4,0x9F,0xF6,0x11,0x11,0x6F,0xFA,0x01,0x11,0x18,0xFF,0x30,
  0x06,0xFF,0x40,0x2E,0xEE,0xEE,0xC0,0x00,0x00,0x0C,0xFE,0x30,0x00,0x03,0xFF,0x60,
  0x08,0xFE,0x10,0x08,0xFE,0xEF,0x30,0x00,0x00,0x03,0xFF,0xC0,0x00,0x02,0xEF,0x80,
  0x09,0xFD,0x10,0x01,0xDE,0xF9,0x00,0x00,0x00,0x00,0x9F,0xF6,0x00,0x01,0xDF,0x90,
  0x09,0xFD,0x10,0x00,0x6F,0xF9,0x00,0x00,0x00,0x00,0x9F,0xED,0x10,0x01,0xDF,0x90,
  0x08,0xFE,0x20,0x00,0x0C,0xFF,0x30,0x00,0x00,0x03,0xFE,0xEF,0x80,0x02,0xEF,0x80,
  0x06,0xFF,0x30,0x00,0x03,0xEF,0xC0,0x00,0x00,0x0C,0xEE,0xEE,0xE2,0x04,0xFF,0x60,
  0x03,0xFF,0x81,0x11,0x10,0xAF,0xF6,0x11,0x11,0x6F,0xF9,0x4F,0xFB,0x07,0xFF,0x30,
  0x00,0xDF,0xEE,0xDD,0xDD,0xDE,0xEE,0xDD,0xDE,0xEE,0xE2,0x0B,0xFF,0x4B,0xFD,0x00,
  0x00,0x9F,0xEF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xEF,0x70,0x03,0xEE,0xEE,0xF9,0x00,
  0x00,0x2E,0xEE,0xA9,0x99,0x99,0xAA,0x99,0xBE,0xED,0x00,0x00,0x9F,0xEE,0xE2,0x00,
  0x00,0x08,0xFE,0x80,0x00,0x00,0x00,0x00,0x9F,0xF5,0x00,0x00,0x1E,0xEF,0x80,0x00,
  0x00,0x01,0xDF,0xF8,0x00,0x00,0x00,0x04,0xFF,0xB0,0x00,0x00,0x7E,0xFD,0x10,0x00,
  0x00,0x00,0x3E,0xEF,0x90,0x00,0x00,0x0C,0xEF,0x30,0x00,0x09,0xFF,0xE3,0x00,0x00,
  0x00,0x00,0x04,0xEF,0xFC,0x50,0x00,0x6F,0xF9,0x00,0x05,0xCF,0xFE,0x40,0x00,0x00,
  0x00,0x00,0x00,0x3C,0xFF,0xFC,0x74,0xDE,0xE3,0x47,0xCF,0xFF,0xC3,0x00,0x00,0x00,
  0x00,0x00,0x00,0x01,0x8E,0xFF,0xFF,0xEE,0xEE,0xFF,0xFF,0xE8,0x10,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x02,0x8D,0xFF,0xFF,0xFF,0xFF,0xD8,0x20,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x36,0x89,0x98,0x63,0x00,0x00,0x00,0x00,0x00,0x00,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
static void ppIconAperture32(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_APERTURE_A4, 32, 32, 16, x + 16, y + 16, c, bg); }
static void ppIconCamera32(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_CAMERA_A4, 32, 32, 16, x + 16, y + 16, c, bg); }
static void ppIconDice32(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_DICE_A4, 32, 32, 16, x + 16, y + 16, c, bg); }
static void ppIconCpu32 (int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_CPU_A4,  32, 32, 16, x + 16, y + 16, c, bg); }
// Card variant with a 32 px icon: the icon column is wider, so the text starts further in.
static void ppCard32(int y, int h, const char* title, const char* desc, bool sel, uint16_t accent,
                     void (*icon)(int, int, uint16_t, uint16_t), uint16_t titleCol = 0){   // titleCol: override the title colour (explainer cards)
  // 7 Oct 2026 (Entropy Ember): the shared list card; 32 px icon at the left.
  // 29 Oct 2026: onboarding cards are brass only (red kept for danger). The
  // green / amber / purple / cyan accents meant nothing to a first-time owner.
  if(accent != C_RED) accent = C_EB_BRASS;
  const int X = 12, W = 216;
  uint16_t bg = uiListCard(X, y, W, h, sel, accent, title, desc, X + 62, titleCol);
  if(icon) icon(X + 14, y + (h - 32) / 2, sel ? accent : C_EB_GREY, bg);
}
#define PP_ICON_N 22
#define PP_ICON_RB 11
static void ppIconWords(int x, int y, uint16_t c, uint16_t){      // a short word list
  const int ly[3] = {3, 10, 17}, ln[3] = {16, 12, 18};
  for(int i = 0; i < 3; i++){ spr.fillRect(x, y + ly[i], 3, 3, c); spr.fillRect(x + 7, y + ly[i] + 1, ln[i], 1, c); }
}
static void ppIconKeys(int x, int y, uint16_t c, uint16_t){       // a keypad: 5x3 keys + space bar
  for(int r = 0; r < 3; r++) for(int k = 0; k < 5; k++) spr.fillRect(x + k*5, y + 2 + r*5, 4, 4, c);
  spr.fillRect(x + 5, y + 17, 14, 3, c);
}
static void ppIconQr(int x, int y, uint16_t c, uint16_t){         // plain QR, no frame: 3 finders + modules
  auto finder = [&](int fx, int fy){ spr.drawRect(fx, fy, 9, 9, c); spr.drawRect(fx + 1, fy + 1, 7, 7, c); spr.fillRect(fx + 3, fy + 3, 3, 3, c); };
  finder(x, y); finder(x + 13, y); finder(x, y + 13);
  spr.fillRect(x + 13, y + 13, 3, 3, c); spr.fillRect(x + 19, y + 13, 3, 3, c);
  spr.fillRect(x + 16, y + 16, 3, 3, c);
  spr.fillRect(x + 13, y + 19, 3, 3, c); spr.fillRect(x + 19, y + 19, 3, 3, c);
  spr.fillRect(x + 11, y + 13, 1, 3, c); spr.fillRect(x + 13, y + 11, 3, 1, c);
}
static void ppIconRedo(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_REDO_A4, PP_ICON_N, PP_ICON_N, PP_ICON_RB, x + 11, y + 11, c, bg); }
static void ppIconTick(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_TICK_A4, PP_ICON_N, PP_ICON_N, PP_ICON_RB, x + 11, y + 11, c, bg); }
static void ppIconKey (int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_KEY_A4,  PP_ICON_N, PP_ICON_N, PP_ICON_RB, x + 11, y + 11, c, bg); }
static void ppIconLock(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_LOCK_A4, PP_ICON_N, PP_ICON_N, PP_ICON_RB, x + 11, y + 11, c, bg); }
static void ppIconDoor(int x, int y, uint16_t c, uint16_t bg){ blitA4(PP_ICON_DOOR_A4, PP_ICON_N, PP_ICON_N, PP_ICON_RB, x + 11, y + 11, c, bg); }
static void ppCard(int y, int h, const char* title, const char* desc, bool sel, uint16_t accent,
                   void (*icon)(int, int, uint16_t, uint16_t)){
  // 7 Oct 2026 (Entropy Ember): the shared list card; 22 px icon at the left.
  if(accent != C_RED) accent = C_EB_BRASS;   // 29 Oct 2026: brass only
  const int X = 12, W = 216;
  uint16_t bg = uiListCard(X, y, W, h, sel, accent, title, desc, X + 52);
  if(icon) icon(X + 14, y + (h - 22) / 2, sel ? accent : C_EB_GREY, bg);
}
#define PP_MAX        100                    // Coldcard / Ledger / Jade cap
#define PP_URL        "favillakey.io/verify/passphrase"

// ── Validation ──────────────────────────────────────────────────────────────
// Returns nullptr when the passphrase is acceptable, else a short reason for
// the screen. Printable ASCII 0x20..0x7E only (space allowed anywhere — never
// stripped), 1..PP_MAX characters.
static const char* ppValidate(const char* s, size_t len){
  if(len==0)      return "Nothing to use";
  if(len>PP_MAX)  return "Over 100 characters";
  for(size_t i=0;i<len;i++){
    unsigned char c=(unsigned char)s[i];
    if(c<0x20 || c>0x7E) return "Not ASCII - plain characters only";
  }
  return nullptr;
}

// ── Master fingerprint from a 64-byte seed ──────────────────────────────────
// HASH160(compressed master pubkey)[0..4], the number Sparrow / Coldcard show.
static bool ppMasterFingerprint(const uint8_t seed[64], uint8_t fp[4]){
  bip32_xprv master;
  if(!bip32_master_from_seed(seed, 64, &master)) return false;
  uint8_t pub[33];
  bool ok = bip32_priv_to_pub_compressed(master.key, pub);
  if(ok){ uint8_t h[20]; hash160(pub, 33, h); memcpy(fp, h, 4); mbedtls_platform_zeroize(h, 20); }
  mbedtls_platform_zeroize(&master, sizeof(master));
  mbedtls_platform_zeroize(pub, sizeof(pub));
  return ok;
}
static void ppFpHex(const uint8_t fp[4], char out[9]){
  snprintf(out, 9, "%02x%02x%02x%02x", fp[0], fp[1], fp[2], fp[3]);
}

// ── Text box: the passphrase in the clear, on a monospace grid ──────────────
// 32 columns of 7 px (JetBrains Mono 12) from x=8, four rows of 16 px, so the
// full 100-character cap fits on screen. Drawn character by character so a
// SPACE gets its own mark (a dim 3x3 block at the baseline) — that is the only
// way a trailing space can be seen, and a passphrase with an invisible extra
// character is a lost wallet. `cursor` appends the amber insertion mark.
#define PP_COLS 32
#define PP_ROWS 4
static void ppDrawText(const char* s, int len, int x0, int y0, bool cursor){
  fSet(F_MONO);
  for(int i=0;i<len && i<PP_COLS*PP_ROWS;i++){
    int col=i%PP_COLS, row=i/PP_COLS;
    int x=x0+col*7, y=y0+row*16;
    if(s[i]==' '){
      spr.fillRect(x+2, y+9, 3, 3, C_DIM);
    } else {
      char one[2]={s[i],0};
      spr.setTextColor(C_FG); spr.drawString(one, x, y);
    }
  }
  fEnd();
  if(cursor && len<PP_COLS*PP_ROWS){
    int col=len%PP_COLS, row=len/PP_COLS;
    spr.fillRect(x0+col*7, y0+row*16+13, 6, 2, C_EB_BRASS);
  }
}
static void ppDrawPanel(const char* s, int len, bool cursor){
  // 6..234 wide (the standard box width), 76 tall: 4 rows + padding.
  uiPanel(6, 24, 228, 76, C_PANEL, C_BORDER2);
  ppDrawText(s, len, 8, 30, cursor);
}
static void ppDrawCount(int len){
  char c[12]; snprintf(c, sizeof c, "%d / %d", len, PP_MAX);
  fSet(F_HEAD_SM); spr.setTextColor(len>PP_MAX ? C_RED : C_DIM);
  fDrawRight(c, 232, 8); fEnd();
}

// ── The reel ────────────────────────────────────────────────────────────────
// Reel picker (25 Sep 2026 redesign). Four character SETS - abc / ABC / 123 /
// symbols - shown as tabs above the reel; SPACE and DONE sit at the start of
// every set so they are always one scroll away. SCROLL moves the reel, a TAP
// on ENTER adds the centred item, a HOLD on ENTER (0.5 s) switches to the next
// set, BACK deletes (or leaves on an empty box). The centre well widens for
// SPACE/DONE so the word fits, and neighbours give way to it.
#define PP_SETS 4
static const char* PP_TAB[PP_SETS] = { "abc", "ABC", "123", "#$%" };
static int ppSetBuild(int set, char* reel){
  int n=0;
  reel[n++]=0;         // DONE  (sentinel)
  reel[n++]=' ';       // SPACE
  if(set==0)      for(char c='a';c<='z';c++) reel[n++]=c;
  else if(set==1) for(char c='A';c<='Z';c++) reel[n++]=c;
  else if(set==2) for(char c='0';c<='9';c++) reel[n++]=c;
  else for(int c=0x21;c<=0x7E;c++){
    if((c>='a'&&c<='z')||(c>='A'&&c<='Z')||(c>='0'&&c<='9')) continue;
    reel[n++]=(char)c;
  }
  return n;
}
static bool ppIsWord(const char* reel, int idx){ return reel[idx]==0 || reel[idx]==' '; }
static const char* ppWord(const char* reel, int idx){ return reel[idx]==0 ? "DONE" : "SPACE"; }

// Draw a string centred on (cx, cy) using the font's own box - both axes.
static void ppCentre(const char* t, int cx, int cy){
  spr.setTextDatum(MC_DATUM); spr.drawString(t, cx, cy); spr.setTextDatum(TL_DATUM);
}
// Reel geometry: cells on a row centred at PP_REEL_Y, 34 px apart; the
// selected cell is a raised 40x52 (74 wide for a word) with a drop shadow.
#define PP_REEL_Y 176
static void ppDrawReelItem(const char* reel, int idx, int cx, int k){
  bool sel = (k == 0);
  if(ppIsWord(reel, idx)){
    uint16_t col = (reel[idx]==0) ? C_EB_BRASS : C_EB_BRASS;
    if(sel){ fSet(F_HEAD); spr.setTextColor(col); ppCentre(ppWord(reel, idx), cx, PP_REEL_Y); fEnd(); }
    else if(reel[idx]==0) spr.fillCircle(cx, PP_REEL_Y, 3, C_EB_BRASS);
    else spr.drawRect(cx-4, PP_REEL_Y-4, 8, 8, C_DIM);
    return;
  }
  char one[2]={reel[idx],0};
  if(sel){ fSet(F_TITLE); spr.setTextColor(C_EB_BRASS); ppCentre(one, cx, PP_REEL_Y); fEnd(); }
  else   { fSet(F_MONO);  spr.setTextColor(abs(k)==1 ? C_TEXT2 : C_DIM); ppCentre(one, cx, PP_REEL_Y); fEnd(); }
}
static void ppDrawReel(const char* reel, int n, int idx, int set){
  // Tabs as pills: the active set filled with an amber outline.
  fSet(F_HEAD_SM);
  for(int t=0;t<PP_SETS;t++){
    int x0 = 16 + t*54; bool act = (t==set);
    if(act) spr.fillRoundRect(x0, 110, 48, 18, 9, C_PANEL2);
    spr.drawRoundRect(x0, 110, 48, 18, 9, act ? C_EB_BRASS : C_BORDER2);
    spr.setTextColor(act ? C_EB_BRASS : C_DIM); ppCentre(PP_TAB[t], x0 + 24, 119);
  }
  fEnd();
  // Selected cell: shadow, panel, outline.
  bool word = ppIsWord(reel, idx);
  int ww = word ? 74 : 40, hh = 52;
  uint16_t oc = (word && reel[idx]==0) ? C_EB_BRASS : C_EB_BRASS;
  spr.fillRoundRect(120-ww/2+2, PP_REEL_Y-hh/2+3, ww, hh, 10, 0x0000);
  spr.fillRoundRect(120-ww/2,   PP_REEL_Y-hh/2,   ww, hh, 10, C_PANEL2);
  spr.drawRoundRect(120-ww/2,   PP_REEL_Y-hh/2,   ww, hh, 10, oc);
  spr.drawRoundRect(120-ww/2+1, PP_REEL_Y-hh/2+1, ww-2, hh-2, 9, oc);
  // Neighbours: 34 px pitch from the cell edge outward.
  for(int k=-3;k<=3;k++){
    if(k==0) continue;
    int j=(idx+k+n)%n;
    int sign=(k<0)?-1:1;
    int cx=120 + sign*(ww/2 + 17) + sign*(abs(k)-1)*34;
    if(cx < 10 || cx > 230) continue;
    ppDrawReelItem(reel, j, cx, k);
  }
  ppDrawReelItem(reel, idx, 120, 0);
  fSet(F_SMALL); spr.setTextColor(C_VDIM); ppCentre("hold ENTER to switch set", 120, 224); fEnd();
}

// ── The picker screen ───────────────────────────────────────────────────────
// Returns true with the passphrase in out (NUL-terminated, len via *lenOut)
// when DONE is chosen with at least one character. Returns false when the
// owner backs out (BACK with nothing entered). The reel position and set are
// remembered across the two passes.
static int g_ppReelPos = 2;   // first letter of the set (after DONE, SPACE)
static int g_ppReelSet = 0;
static bool ppPicker(const char* title, uint16_t titleCol, char* out, int* lenOut){
  char reel[48]; int set=g_ppReelSet; int n=ppSetBuild(set, reel);
  int len=0; out[0]=0;
  int idx=g_ppReelPos; if(idx>=n) idx=2;

  delay(200);
  btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
  btn1.resetHold(); btn2.resetHold(); btn3.resetHold(); btn4.resetHold();
  clearButtonPending();

  bool redraw=true;
  while(true){
    if(redraw){
      spr.fillSprite(C_BG);
      fSet(F_HEAD_SM); spr.setTextColor(titleCol); spr.drawString(title, 8, 8); fEnd();
      ppDrawCount(len);
      ppDrawPanel(out, len, true);
      ppDrawReel(reel, n, idx, set);
      dispPush();
      redraw=false;
    }
    btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
    float hDown=btn1.holdProgress(450);
    float hUp  =btn3.holdProgress(450);
    if(btn1.isPressed() || hDown>=1.0f){ idx=(idx+1)%n; redraw=true; delay(hDown>=1.0f ? 45 : 110); continue; }
    if(btn3.isPressed() || hUp>=1.0f){ idx=(idx+n-1)%n; redraw=true; delay(hUp>=1.0f ? 45 : 110); continue; }
    // ENTER: the press edge fires isPressed(); decide tap vs hold by watching
    // the release. Released inside 500 ms = tap (add the item). Still down at
    // 500 ms = hold (next set), then wait for the release so it can't repeat.
    if(btn2.isPressed()){
      unsigned long t0=millis(); bool held=false;
      while(btn2.stable==LOW){
        btn2.poll(); esp_task_wdt_reset(); delay(5);
        if(millis()-t0 >= 500){ held=true; break; }
      }
      if(held){
        set=(set+1)%PP_SETS; n=ppSetBuild(set, reel); idx=2;
        buzzerClick();
        while(btn2.stable==LOW){ btn2.poll(); esp_task_wdt_reset(); delay(5); }
        btn2.disarm(); btn2.resetHold();
        redraw=true; continue;
      }
      if(reel[idx]==0){                     // DONE
        clearButtonPending();
        if(len==0) return false;
        g_ppReelPos=idx; g_ppReelSet=set; *lenOut=len; out[len]=0;
        buzzerOK();
        return true;
      }
      if(len<PP_MAX){ out[len++]=reel[idx]; out[len]=0; }
      else buzzerFail();
      redraw=true; delay(60); continue;
    }
    if(btn4.isPressed()){
      if(len>0){ out[--len]=0; redraw=true; delay(110); continue; }
      clearButtonPending();
      g_ppReelPos=idx; g_ppReelSet=set;
      mbedtls_platform_zeroize(out, PP_MAX+1);
      return false;
    }
    esp_task_wdt_reset();
    delay(10);
  }
}

// A red-accent notice with one forward action on ENTER, BACK to retreat.
// Used for the CREATE-time consequence ("words alone will NOT recover your
// funds") and for the QR pre-scan warning.
// 29 Oct 2026 (page language): red tracked title, two ink lines, two grey
// lines, the URL in brass mono, then the action as a tracked footer. `hold`
// makes the action a 1.5 s hold of ENTER (used for the "words alone will NOT
// recover your funds" consequence, which used to be a single tap on a pill).
// BACK retreats.
static bool ppNotice(const char* title, const char* l1, const char* l2,
                     const char* l3, const char* l4, const char* url,
                     const char* action, bool hold = false, uint16_t titleCol = C_RED){
  clearButtonPending();
  char up[40];
  auto draw = [&](float hp){
    spr.fillSprite(C_BG);
    uiTrackLabel(uiUpper(title, up, sizeof up), 120, 14, titleCol);
    fEndHard(); spr.loadFont(FONT_Archivo_Regular_13);
    spr.setTextColor(C_EB_INK);
    if(l1) fDrawCentre(l1, 120, 52);
    if(l2) fDrawCentre(l2, 120, 70);
    spr.setTextColor(C_EB_GREY);
    if(l3) fDrawCentre(l3, 120, 100);
    if(l4) fDrawCentre(l4, 120, 118);
    fEndHard();
    if(url){ fSet(F_MONO); spr.setTextColor(C_EB_BRASS); fDrawCentre(url, 120, 148); }
    if(hold) uiHoldFooter(action, hp > 0 ? "Let go to stop" : "BACK goes back", hp, C_RED);
    else {   // 23 Nov 2026 (Josh): the answers in the corners, no hint line
      spr.fillRect(0, 196, 240, 44, C_BG);
      const char* yes = !strncmp(action, "ENTER TO ", 9) ? action + 9 : action;
      uiCornerAnswers("BACK", yes);
    }
  };
  draw(0); dispPush();
  unsigned long shown = millis(); float last = 0;
  while(true){
    btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
    if(btn4.isPressed()){ clearButtonPending(); return false; }
    if(!hold){ if(btn2.isPressed()){ clearButtonPending(); return true; } }
    else {
      btn2.isPressed();
      float hp = holdSince(btn2, shown, 1500);
      if(hp >= 1.0f){ btn2.resetHold(); clearButtonPending(); return true; }
      if(hp > 0 || last > 0){ uiHoldFooter(action, hp > 0 ? "Let go to stop" : "BACK goes back", hp, C_RED); dispPushRegion(0, 196, 240, 44); last = hp; }
    }
    esp_task_wdt_reset(); delay(10);
  }
}

// ── TYPE: enter twice ───────────────────────────────────────────────────────
// The first pass is kept; only the second is repeated on a mismatch. BACK on
// an empty second pass returns to the first (edit it); BACK on an empty first
// pass returns false (back to the method choice).
// Once, not twice (25 Sep 2026). The second pass only ever guarded against
// typos in a MASKED entry (Trezor, Ledger). Ours is visible as you type and
// the fingerprint screen follows, which catches a wrong passphrase in a way
// that retyping the same typo twice never could. Name kept so callers stand.
static bool ppTypeTwice(char* out, size_t cap){
  char a[PP_MAX+1]={0};
  struct Wipe { char *a; ~Wipe(){ mbedtls_platform_zeroize(a,PP_MAX+1);} } _w{a};
  int la=0;
  if(!ppPicker("PASSPHRASE", C_MUTED, a, &la)) return false;
  strncpy(out, a, cap-1); out[cap-1]=0;
  return true;
}

// ── SCAN QR: warning, scan, validate, review ────────────────────────────────
// Mirrors the SEED QR restore path exactly (same camera entry sequence, same
// synchronous qrScanOnce loop, same 30 s window). The payload is the raw
// passphrase text — nothing is trimmed. The pre-scan notice carries the same
// consequence as the seed QR: whoever reads the QR reads the passphrase.
static bool ppScan(char* out, size_t cap){
  while(true){
    if(!ppNotice("Passphrase QR",
                 "Anyone who reads this QR",
                 "can read your passphrase.",
                 "Make it on a machine kept",
                 "offline for good, then scan:",
                 PP_URL, "ENTER TO SCAN")) return false;

    spr.fillSprite(C_BG);
    uiAsk("Scan passphrase QR", "Hold the screen to the camera");
    dispPush(); delay(600);
    pwrBoost();       // grab+decode+preview MUST run at 240MHz
    camHoldWake();    // 11bj: the scan's own hold, as every other scan since 10q/11b. pmHoldWake()
                      // here held off light sleep but not the power manager's clock locks, so on
                      // the light-sleep builds the camera crawled (frames lost, nothing decoded),
                      // and cameraStop() never released it, so light sleep stayed off all life.
    cameraStart(); qrFound=false;
    if(!cameraRunning) return false;   // start failed - error screen already shown
    for(int _f=0; _f<4; _f++){          // stale-frame flush (fb_count=1 resident)
      camera_fb_t* _sf=esp_camera_fb_get();
      if(_sf) esp_camera_fb_return(_sf);
      vTaskDelay(pdMS_TO_TICKS(25));
    }
    qrResultBuf[0]=0;
    qrDiagReset(); qrDumpReset();
    g_airgapLivePreview=true; g_airgapUrGot=0; g_airgapUrTotal=0;
    unsigned long qs=millis(), lastQR=0;
    bool got=false;
    while(millis()-qs<30000){
      btn4.poll();
      if(btn4.isPressed()){ g_airgapLivePreview=false; cameraStop(); break; }   // BACK = cancel
      if(!qrFound&&(millis()-lastQR>QR_AIRGAP_SCAN_INTERVAL_MS)){
        qrScanOnce(); lastQR=millis(); delay(5);
      }
      if(qrFound){
        qrFound=false; g_airgapLivePreview=false; cameraStop();
        clearButtonPending();
        got=true; break;
      }
      delay(10);
    }
    if(!got){ g_airgapLivePreview=false; cameraStop(); continue; }   // back to the notice

    // Validate. NEVER log the payload — it is the passphrase.
    size_t len=strnlen(qrResultBuf, QR_RESULT_SZ);
    const char* why=ppValidate(qrResultBuf, len);
    LOG_KEY("[PASS] QR scanned (%d chars) %s\n", (int)len, why ? "REJECTED" : "ok");
    if(why){
      mbedtls_platform_zeroize(qrResultBuf, QR_RESULT_SZ);
      dispError(why); errorPause();
      continue;                          // back to the notice, scan again
    }
    char tmp[PP_MAX+1]; memcpy(tmp, qrResultBuf, len); tmp[len]=0;
    mbedtls_platform_zeroize(qrResultBuf, QR_RESULT_SZ);

    // Review: the scanned text in the clear, with its length and every
    // space marked, then ACCEPT / SCAN AGAIN.
    int sel=0; bool decided=false, accept=false;
    clearButtonPending();
    while(!decided){
      spr.fillSprite(C_BG);
      fSet(F_HEAD_SM); spr.setTextColor(C_MUTED); spr.drawString("SCANNED", 8, 8); fEnd();
      ppDrawCount((int)len);
      ppDrawPanel(tmp, (int)len, false);
      ppCard(110, 58, "USE IT",     "Every character is shown", sel==0, C_EB_BRASS, ppIconTick);
      ppCard(176, 58, "SCAN AGAIN", "Something is off",         sel==1, C_EB_BRASS, ppIconRedo);
      dispPush();
      while(true){
        btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
        if(btn1.isPressed()||btn3.isPressed()){ sel = sel ? 0 : 1; break; }
        if(btn2.isPressed()){ accept=(sel==0); decided=true; break; }
        if(btn4.isPressed()){ accept=false; decided=true; break; }
        esp_task_wdt_reset(); delay(10);
      }
      delay(180);
    }
    clearButtonPending();
    if(accept){
      strncpy(out, tmp, cap-1); out[cap-1]=0;
      mbedtls_platform_zeroize(tmp, sizeof tmp);
      buzzerOK();
      return true;
    }
    mbedtls_platform_zeroize(tmp, sizeof tmp);
    // SCAN AGAIN → loop to the notice.
  }
}

// ── v4 (24 Sep 2026): the MODE choice, and the door prompt ────────────────
// Three ways a wallet can relate to a passphrase:
//   PP_MODE_NONE     no passphrase
//   PP_MODE_BAKED    consumed at create/restore, never asked again (the
//                    derived seed is sealed)
//   PP_MODE_SESSION  the ENTROPY is sealed; the Bitcoin door asks for the
//                    passphrase each power-on life and the G0 derives from
//                    it. Nostr derives from the words alone in this mode, so
//                    the passphrase is a purely Bitcoin secret. Switching a
//                    wallet between modes means wipe + restore.
#define PP_MODE_NONE    0
#define PP_MODE_BAKED   1
#define PP_MODE_SESSION 2

// Screen: NONE / BAKE IT IN / EACH SESSION. Returns the mode, or -1 on BACK.
static int ppModeChoice(bool restoreMode){
  int sel=0;
  clearButtonPending();
  while(true){
    spr.fillSprite(C_BG);
    if(restoreMode) uiAsk("Passphrase?", "Only if your wallet used one");
    else            uiAsk("Add a passphrase?", "Optional - most owners skip this");
    ppCard(46, 62, "NONE",         restoreMode ? "Just the words" : "Recommended", sel==0, C_EB_BRASS, ppIconWords);
    // 29 Oct 2026: the names say the trade - stored on the KEY, or never stored.
    ppCard(114,62, "STORE IT",      "Type it once only",            sel==1, C_EB_BRASS, ppIconLock);
    ppCard(182,56, "ASK EACH TIME", "Never stored on the KEY",                    sel==2, C_EB_BRASS, ppIconDoor);
    dispPush();
    while(true){
      btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
      if(btn1.isPressed()){ sel=(sel+1)%3; break; }
      if(btn3.isPressed()){ sel=(sel+2)%3; break; }
      if(btn2.isPressed()){ clearButtonPending(); return sel; }
      if(btn4.isPressed()){ clearButtonPending(); return -1; }
      esp_task_wdt_reset(); delay(10);
    }
    delay(180);
  }
}

// Entry method for the chosen mode. allowSkip (per-session) adds a third
// card: skip the rehearsal and check the fingerprint at the door instead.
// Returns 1 passphrase in out, 0 skipped, -1 back.
static int ppEntryMethod(char* out, size_t cap, bool allowSkip){
  int sel=0;
  clearButtonPending();
  while(true){
    bool decided=false;
    while(!decided){
      spr.fillSprite(C_BG);
      // 29 Oct 2026: in ask-each-time mode this step is a CHECK (the typed
      // passphrase only produces the fingerprint; nothing is sealed), so say so.
      if(allowSkip){
        uiAsk("Check it now", "Type it once to see the fingerprint");
        ppCard(46, 62, "TYPE TO CHECK",  "Nothing is saved", sel==0, C_EB_BRASS, ppIconKeys);
        ppCard(114,62, "SCAN TO CHECK",  "From a QR you made",            sel==1, C_EB_BRASS, ppIconQr);
        ppCard(182,56, "SKIP THE CHECK", "Check at the Bitcoin door",     sel==2, C_EB_BRASS, ppIconDoor);
      } else {
        uiAsk("Enter the passphrase", "Type it, or scan a QR");
        ppCard(46, 62, "TYPE",    "With the buttons",          sel==0, C_EB_BRASS, ppIconKeys);
        ppCard(114,62, "SCAN QR", "Made with a QR generator",  sel==1, C_EB_BRASS, ppIconQr);
      }
      dispPush();
      int n = allowSkip ? 3 : 2;
      while(true){
        btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
        if(btn1.isPressed()){ sel=(sel+1)%n; break; }
        if(btn3.isPressed()){ sel=(sel+n-1)%n; break; }
        if(btn2.isPressed()){ decided=true; break; }
        if(btn4.isPressed()){ clearButtonPending(); return -1; }
        esp_task_wdt_reset(); delay(10);
      }
      delay(180);
    }
    clearButtonPending();
    if(sel==2){ out[0]=0; return 0; }
    bool ok = (sel==0) ? ppTypeTwice(out, cap) : ppScan(out, cap);
    if(ok) return 1;
    sel=0;
  }
}

// 23 Nov 2026 (Josh: "are pics 2 and 3 really good UX?"): ASK EACH TIME is one
// screen, not a notice and then a three-way choice. It says what the mode
// means and offers the one useful thing now, typing it once to see the
// fingerprint. SKIP (BACK) and TYPE (ENTER) in the corners. Scanning a
// passphrase QR stays at the Bitcoin door, where it is used.
// Returns 1 typed (out holds it), 0 skipped.
static int ppCheckNow(char* out, size_t cap){
  while(true){
    spr.fillSprite(C_BG);
    uiTrackLabel("ASK EACH TIME", 120, 14, C_EB_BRASS);
    fEndHard(); spr.loadFont(FONT_Archivo_Bold_28_full); spr.setTextColor(C_EB_INK);
    spr.drawString("Check it now", 120 - spr.textWidth("Check it now") / 2, 44);
    fEndHard(); spr.loadFont(FONT_Archivo_Regular_13); spr.setTextColor(C_EB_GREY);
    static const char* const L[3] = { "You type it at the Bitcoin door", "after every power on. Type it", "once now to see its fingerprint." };
    for(int i = 0; i < 3; i++) spr.drawString(L[i], 120 - spr.textWidth(L[i]) / 2, 92 + 18 * i);
    fEndHard();
    fSet(F_BODY); spr.setTextColor(C_EB_GREY);
    fDrawCentre("Nostr only needs the words.", 120, 154);
    fDrawCentre("Changing it later: wipe and restore.", 120, 170);
    fEnd();
    uiCornerAnswers("SKIP", "TYPE");
    dispPush(); clearButtonPending();
    while(true){
      btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
      if(btn4.isPressed()){ clearButtonPending(); out[0] = 0; return 0; }
      if(btn2.isPressed()){ clearButtonPending(); break; }
      esp_task_wdt_reset(); delay(10);
    }
    if(ppTypeTwice(out, cap)) return 1;   // BACK while typing comes back here
  }
}

// The full onboarding step: mode, notices, entry. Returns the mode or -1
// (BACK on the mode screen: at restore "abandon", at create "none"). For
// PP_MODE_BAKED out holds the passphrase. For PP_MODE_SESSION out holds it
// only if the owner typed it as a rehearsal (*rehearsed = true); nothing is
// ever sealed from it in that mode.
static int ppCollectMode(char* out, size_t cap, bool restoreMode, bool* rehearsed){
  *rehearsed=false; out[0]=0;
  while(true){
    int mode = ppModeChoice(restoreMode);
    if(mode<0) return -1;
    if(mode==PP_MODE_NONE) return PP_MODE_NONE;
    if(!restoreMode){
      if(!ppNotice("Read this first",
                   "Your words alone will NOT",
                   "recover your funds.",
                   "You must also remember the",
                   "passphrase, exactly. Forever.",
                   nullptr, "HOLD ENTER TO CONFIRM", true)) continue;
    }
    if(mode==PP_MODE_SESSION){
      // 29 Oct 2026: full sentences (the fragments read like notes).
      // 29 Oct 2026: an explanation, not a warning, so brass. Says what
      // happens and what switching later costs.
      *rehearsed = (ppCheckNow(out, cap) == 1);   // 23 Nov 2026: one screen (was a notice + TYPE/SCAN/SKIP)
      return PP_MODE_SESSION;
    }
    int e = ppEntryMethod(out, cap, false);
    if(e<0) continue;
    return PP_MODE_BAKED;
  }
}

// The Bitcoin door prompt for a per-session wallet. NONE is the words-only
// wallet (a zero-length passphrase), TYPE / SCAN QR open whichever wallet the
// answer produces. Returns 0 with out = "" for NONE, 1 with the passphrase,
// -1 on BACK (leave the door). Every answer is a valid wallet: nothing here
// can tell a decoy from the real one, by design.
static int ppCollectDoor(char* out, size_t cap){
  int sel=0; out[0]=0;
  clearButtonPending();
  while(true){
    bool decided=false;
    while(!decided){
      spr.fillSprite(C_BG);
      uiAsk("Passphrase", "Each passphrase is its own wallet");
      ppCard(46, 62, "NONE",    "Words only, no passphrase", sel==0, C_EB_BRASS, ppIconWords);
      ppCard(114,62, "TYPE",    "Enter it with the buttons", sel==1, C_EB_BRASS, ppIconKeys);
      ppCard(182,56, "SCAN QR", "Made with a QR generator",     sel==2, C_EB_BRASS, ppIconQr);
      dispPush();
      while(true){
        btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
        if(btn1.isPressed()){ sel=(sel+1)%3; break; }
        if(btn3.isPressed()){ sel=(sel+2)%3; break; }
        if(btn2.isPressed()){ decided=true; break; }
        if(btn4.isPressed()){ clearButtonPending(); return -1; }
        esp_task_wdt_reset(); delay(10);
      }
      delay(180);
    }
    clearButtonPending();
    if(sel==0){ out[0]=0; return 0; }
    bool ok = (sel==1) ? ppTypeTwice(out, cap) : ppScan(out, cap);
    if(ok) return 1;
    sel=0;
  }
}

// ── Fingerprint confirm ─────────────────────────────────────────────────────
// Mandatory after derivation on both paths. With a passphrase BOTH numbers
// are shown: the words-only fingerprint (what Sparrow shows for the bare
// words) and the final one (what this wallet is). At restore the owner
// matches the final number against the wallet they are restoring; a wrong
// passphrase is caught HERE, before the seed is sealed, instead of by an empty
// balance later. Returns true to proceed, false to go back to the passphrase
// choice.
static bool ppFingerprintConfirm(const uint8_t fpWords[4], const uint8_t fpFinal[4],
                                 bool hasPass, bool restoreMode){
  char hw[9], hf[9]; ppFpHex(fpWords, hw); ppFpHex(fpFinal, hf);
  int sel=0;
  clearButtonPending();
  while(true){
    spr.fillSprite(C_BG);
    if(restoreMode) uiAsk("Wallet fingerprint", "Match the wallet you are restoring");
    else            uiAsk("Wallet fingerprint", hasPass ? "Write both next to your words" : "Write it next to your words");
    if(hasPass){
      fSet(F_HEAD_SM); spr.setTextColor(C_DIM);  spr.drawString("WORDS ONLY", 24, 52); fEnd();
      fSet(F_TITLE);   spr.setTextColor(C_DIM);  fDrawCentre(hw, 120, 64); fEnd();
      fSet(F_HEAD_SM); spr.setTextColor(C_EB_BRASS); spr.drawString("WITH PASSPHRASE", 24, 98); fEnd();
      fSet(F_TITLE);   spr.setTextColor(C_EB_BRASS); fDrawCentre(hf, 120, 110); fEnd();
    } else {
      fSet(F_TITLE); spr.setTextColor(C_EB_BRASS); fDrawCentre(hf, 120, 62); fEnd();
      fSet(F_BODY);  spr.setTextColor(C_MUTED);
      if(restoreMode){
        fDrawCentre("Compare with Sparrow or Coldcard", 120, 100);
        fDrawCentre("A different number = wrong entry", 120, 118);
      } else {
        fDrawCentre("A restore that shows a different", 120, 100);
        fDrawCentre("number has the wrong words.", 120, 118);
      }
      fEnd();
    }
    // 29 Oct 2026: with NONE chosen, don't offer "ADD ONE" here - the owner
    // just said no, so asking again second-guesses them. One action as a
    // tracked footer; BACK still returns to the passphrase choice (the
    // restore case says so, since a mismatch there can mean a forgotten
    // passphrase). With a passphrase, keep the two cards (CHANGE IT is useful).
    if(!hasPass){
      uiTrackLabel(restoreMode ? "ENTER IF IT MATCHES" : "ENTER TO CONTINUE", 120, 196, C_EB_BRASS);
      fSet(F_SMALL); spr.setTextColor(C_EB_GREY);
      fDrawCentre(restoreMode ? "No match? BACK to add a passphrase" : "BACK goes back", 120, 218);
      dispPush();
      while(true){
        btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
        if(btn2.isPressed()){ clearButtonPending(); return true; }
        if(btn4.isPressed()){ clearButtonPending(); return false; }
        esp_task_wdt_reset(); delay(10);
      }
    }
    const char* aT = restoreMode ? "IT MATCHES" : "CONTINUE";
    const char* bT = "CHANGE IT";
    ppCard(146, 40, aT, "", sel==0, C_EB_BRASS, ppIconTick);
    ppCard(192, 40, bT, "", sel==1, C_EB_BRASS, ppIconRedo);
    dispPush();
    while(true){
      btn1.poll(); btn2.poll(); btn3.poll(); btn4.poll();
      if(btn1.isPressed()||btn3.isPressed()){ sel = sel ? 0 : 1; break; }
      if(btn2.isPressed()){ clearButtonPending(); return sel==0; }
      if(btn4.isPressed()){ clearButtonPending(); return false; }
      esp_task_wdt_reset(); delay(10);
    }
    delay(180);
  }
}
